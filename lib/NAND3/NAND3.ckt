* SPICE netlist generated by Yosys 0.33 (git sha1 2584903a060)

X0 A int1 GND NMOS
X1 B int2 int1 NMOS
X2 C Y int2 NMOS
X3 A Y VDD PMOS
X4 B Y VDD PMOS
X5 C Y VDD PMOS
V0 GND GND DC 0
V1 VDD VDD DC 0

************************
* end of SPICE netlist *
************************
