* PWL waveform for A
VA A 0 PWL(0.0n 0.0V 30.0n 0.0V 200.0n 0.0V 230.0n 3.3V 400.0n 3.3V 430.0n 0.0V 600.0n 0.0V 630.0n 0.0V 800.0n 0.0V 830.0n 0.0V 1000.0n 0.0V 1030.0n 3.3V 1200.0n 3.3V 1230.0n 0.0V 1400.0n 0.0V 1430.0n 0.0V 1600.0n 0.0V 1630.0n 0.0V 1800.0n 0.0V 1830.0n 3.3V 2000.0n 3.3V 2030.0n 0.0V 2200.0n 0.0V 2230.0n 0.0V 2400.0n 0.0V 2430.0n 0.0V 2600.0n 0.0V 2630.0n 3.3V 2800.0n 3.3V 2830.0n 0.0V 3000.0n 0.0V 3030.0n 0.0V 3200.0n 0.0V 3230.0n 0.0V 3400.0n 0.0V 3430.0n 3.3V 3600.0n 3.3V 3630.0n 0.0V 3800.0n 0.0V 3830.0n 0.0V 4000.0n 0.0V 4030.0n 0.0V 4200.0n 0.0V 4230.0n 3.3V 4400.0n 3.3V 4430.0n 0.0V 4600.0n 0.0V 4630.0n 0.0V 4800.0n 0.0V 4830.0n 0.0V 5000.0n 0.0V 5030.0n 3.3V 5200.0n 3.3V 5230.0n 0.0V 5400.0n 0.0V 5430.0n 0.0V 5600.0n 0.0V 5630.0n 0.0V 5800.0n 0.0V 5830.0n 3.3V 6000.0n 3.3V 6030.0n 3.3V 6200.0n 3.3V 6230.0n 0.0V 6400.0n 0.0V 6430.0n 3.3V 6600.0n 3.3V 6630.0n 3.3V 6800.0n 3.3V 6830.0n 3.3V 7000.0n 3.3V 7030.0n 0.0V 7200.0n 0.0V 7230.0n 3.3V 7400.0n 3.3V 7430.0n 3.3V 7600.0n 3.3V 7630.0n 3.3V 7800.0n 3.3V 7830.0n 0.0V 8000.0n 0.0V 8030.0n 3.3V 8200.0n 3.3V 8230.0n 3.3V 8400.0n 3.3V 8430.0n 3.3V 8600.0n 3.3V 8630.0n 0.0V 8800.0n 0.0V 8830.0n 3.3V 9000.0n 3.3V 9030.0n 3.3V 9200.0n 3.3V 9230.0n 3.3V 9400.0n 3.3V 9430.0n 0.0V 9600.0n 0.0V 9630.0n 3.3V 9800.0n 3.3V 9830.0n 3.3V 10000.0n 3.3V 10030.0n 3.3V 10200.0n 3.3V 10230.0n 0.0V 10400.0n 0.0V 10430.0n 3.3V 10600.0n 3.3V 10630.0n 3.3V 10800.0n 3.3V 10830.0n 3.3V 11000.0n 3.3V 11030.0n 0.0V 11200.0n 0.0V 11230.0n 3.3V 11400.0n 3.3V 11430.0n 3.3V 11600.0n 3.3V 11630.0n 0.0V 11800.0n 0.0V 11830.0n 3.3V 12000.0n 3.3V 12030.0n 0.0V 12200.0n 0.0V 12230.0n 0.0V 12400.0n 0.0V 12430.0n 0.0V 12600.0n 0.0V 12630.0n 3.3V 12800.0n 3.3V 12830.0n 0.0V 13000.0n 0.0V 13030.0n 0.0V 13200.0n 0.0V 13230.0n 0.0V 13400.0n 0.0V 13430.0n 3.3V 13600.0n 3.3V 13630.0n 0.0V 13800.0n 0.0V 13830.0n 0.0V 14000.0n 0.0V 14030.0n 0.0V 14200.0n 0.0V 14230.0n 3.3V 14400.0n 3.3V 14430.0n 0.0V 14600.0n 0.0V 14630.0n 0.0V 14800.0n 0.0V 14830.0n 0.0V 15000.0n 0.0V 15030.0n 3.3V 15200.0n 3.3V 15230.0n 0.0V 15400.0n 0.0V 15430.0n 0.0V 15600.0n 0.0V 15630.0n 0.0V 15800.0n 0.0V 15830.0n 3.3V 16000.0n 3.3V 16030.0n 0.0V 16200.0n 0.0V 16230.0n 0.0V 16400.0n 0.0V 16430.0n 0.0V 16600.0n 0.0V 16630.0n 3.3V 16800.0n 3.3V 16830.0n 3.3V 17000.0n 3.3V 17030.0n 0.0V 17200.0n 0.0V 17230.0n 3.3V 17400.0n 3.3V 17430.0n 3.3V 17600.0n 3.3V 17630.0n 3.3V 17800.0n 3.3V 17830.0n 0.0V 18000.0n 0.0V 18030.0n 3.3V 18200.0n 3.3V 18230.0n 3.3V 18400.0n 3.3V 18430.0n 3.3V 18600.0n 3.3V 18630.0n 0.0V 18800.0n 0.0V 18830.0n 3.3V 19000.0n 3.3V 19030.0n 3.3V 19200.0n 3.3V 19230.0n 3.3V 19400.0n 3.3V 19430.0n 0.0V 19600.0n 0.0V 19630.0n 3.3V 19800.0n 3.3V 19830.0n 3.3V 20000.0n 3.3V 20030.0n 3.3V 20200.0n 3.3V 20230.0n 0.0V 20400.0n 0.0V 20430.0n 3.3V 20600.0n 3.3V 20630.0n 3.3V 20800.0n 3.3V 20830.0n 3.3V 21000.0n 3.3V 21030.0n 0.0V 21200.0n 0.0V 21230.0n 3.3V 21400.0n 3.3V 21430.0n 3.3V 21600.0n 3.3V 21630.0n 0.0V 21800.0n 0.0V 21830.0n 3.3V 22000.0n 3.3V 22030.0n 0.0V 22200.0n 0.0V 22230.0n 0.0V 22400.0n 0.0V 22430.0n 0.0V 22600.0n 0.0V 22630.0n 3.3V 22800.0n 3.3V 22830.0n 0.0V 23000.0n 0.0V 23030.0n 0.0V 23200.0n 0.0V 23230.0n 0.0V 23400.0n 0.0V 23430.0n 3.3V 23600.0n 3.3V 23630.0n 0.0V 23800.0n 0.0V 23830.0n 0.0V 24000.0n 0.0V 24030.0n 0.0V 24200.0n 0.0V 24230.0n 3.3V 24400.0n 3.3V 24430.0n 0.0V 24600.0n 0.0V 24630.0n 0.0V 24800.0n 0.0V 24830.0n 0.0V 25000.0n 0.0V 25030.0n 3.3V 25200.0n 3.3V 25230.0n 0.0V 25400.0n 0.0V 25430.0n 0.0V 25600.0n 0.0V 25630.0n 0.0V 25800.0n 0.0V 25830.0n 3.3V 26000.0n 3.3V 26030.0n 3.3V 26200.0n 3.3V 26230.0n 0.0V 26400.0n 0.0V 26430.0n 3.3V 26600.0n 3.3V 26630.0n 3.3V 26800.0n 3.3V 26830.0n 3.3V 27000.0n 3.3V 27030.0n 0.0V 27200.0n 0.0V 27230.0n 3.3V 27400.0n 3.3V 27430.0n 3.3V 27600.0n 3.3V 27630.0n 3.3V 27800.0n 3.3V 27830.0n 0.0V 28000.0n 0.0V 28030.0n 3.3V 28200.0n 3.3V 28230.0n 3.3V 28400.0n 3.3V 28430.0n 3.3V 28600.0n 3.3V 28630.0n 0.0V 28800.0n 0.0V 28830.0n 3.3V 29000.0n 3.3V 29030.0n 3.3V 29200.0n 3.3V 29230.0n 3.3V 29400.0n 3.3V 29430.0n 0.0V 29600.0n 0.0V 29630.0n 3.3V 29800.0n 3.3V 29830.0n 3.3V 30000.0n 3.3V 30030.0n 0.0V 30200.0n 0.0V 30230.0n 3.3V 30400.0n 3.3V 30430.0n 0.0V 30600.0n 0.0V 30630.0n 0.0V 30800.0n 0.0V 30830.0n 0.0V 31000.0n 0.0V 31030.0n 3.3V 31200.0n 3.3V 31230.0n 0.0V 31400.0n 0.0V 31430.0n 0.0V 31600.0n 0.0V 31630.0n 0.0V 31800.0n 0.0V 31830.0n 3.3V 32000.0n 3.3V 32030.0n 0.0V 32200.0n 0.0V 32230.0n 0.0V 32400.0n 0.0V 32430.0n 0.0V 32600.0n 0.0V 32630.0n 3.3V 32800.0n 3.3V 32830.0n 0.0V 33000.0n 0.0V 33030.0n 0.0V 33200.0n 0.0V 33230.0n 0.0V 33400.0n 0.0V 33430.0n 3.3V 33600.0n 3.3V 33630.0n 3.3V 33800.0n 3.3V 33830.0n 0.0V 34000.0n 0.0V 34030.0n 3.3V 34200.0n 3.3V 34230.0n 3.3V 34400.0n 3.3V 34430.0n 3.3V 34600.0n 3.3V 34630.0n 0.0V 34800.0n 0.0V 34830.0n 3.3V 35000.0n 3.3V 35030.0n 3.3V 35200.0n 3.3V 35230.0n 3.3V 35400.0n 3.3V 35430.0n 0.0V 35600.0n 0.0V 35630.0n 3.3V 35800.0n 3.3V 35830.0n 3.3V 36000.0n 3.3V 36030.0n 3.3V 36200.0n 3.3V 36230.0n 0.0V 36400.0n 0.0V 36430.0n 3.3V 36600.0n 3.3V 36630.0n 3.3V 36800.0n 3.3V 36830.0n 0.0V 37000.0n 0.0V 37030.0n 3.3V 37200.0n 3.3V 37230.0n 0.0V 37400.0n 0.0V 37430.0n 0.0V 37600.0n 0.0V 37630.0n 0.0V 37800.0n 0.0V 37830.0n 3.3V 38000.0n 3.3V 38030.0n 0.0V 38200.0n 0.0V 38230.0n 0.0V 38400.0n 0.0V 38430.0n 0.0V 38600.0n 0.0V 38630.0n 3.3V 38800.0n 3.3V 38830.0n 0.0V 39000.0n 0.0V 39030.0n 0.0V 39200.0n 0.0V 39230.0n 0.0V 39400.0n 0.0V 39430.0n 3.3V 39600.0n 3.3V 39630.0n 3.3V 39800.0n 3.3V 39830.0n 0.0V 40000.0n 0.0V 40030.0n 3.3V 40200.0n 3.3V 40230.0n 3.3V 40400.0n 3.3V 40430.0n 3.3V 40600.0n 3.3V 40630.0n 0.0V 40800.0n 0.0V 40830.0n 3.3V 41000.0n 3.3V 41030.0n 3.3V 41200.0n 3.3V 41230.0n 3.3V 41400.0n 3.3V 41430.0n 0.0V 41600.0n 0.0V 41630.0n 3.3V 41800.0n 3.3V 41830.0n 3.3V 42000.0n 3.3V 42030.0n 0.0V 42200.0n 0.0V 42230.0n 3.3V 42400.0n 3.3V 42430.0n 0.0V 42600.0n 0.0V 42630.0n 0.0V 42800.0n 0.0V 42830.0n 0.0V 43000.0n 0.0V 43030.0n 3.3V 43200.0n 3.3V 43230.0n 0.0V 43400.0n 0.0V 43430.0n 0.0V 43600.0n 0.0V 43630.0n 0.0V 43800.0n 0.0V 43830.0n 3.3V 44000.0n 3.3V 44030.0n 3.3V 44200.0n 3.3V 44230.0n 0.0V 44400.0n 0.0V 44430.0n 3.3V 44600.0n 3.3V 44630.0n 3.3V 44800.0n 3.3V 44830.0n 3.3V 45000.0n 3.3V 45030.0n 0.0V 45200.0n 0.0V 45230.0n 3.3V 45400.0n 3.3V 45430.0n 3.3V 45600.0n 3.3V 45630.0n 0.0V 45800.0n 0.0V 45830.0n 3.3V 46000.0n 3.3V 46030.0n 0.0V 46200.0n 0.0V 46230.0n 0.0V 46400.0n 0.0V 46430.0n 0.0V 46600.0n 0.0V 46630.0n 3.3V 46800.0n 3.3V 46830.0n 3.3V 47000.0n 3.3V 47030.0n 0.0V 47200.0n 0.0V 47230.0n 3.3V 47400.0n 3.3V 47430.0n 3.3V 47600.0n 3.3V 47630.0n 0.0V 47800.0n 0.0V 47830.0n 3.3V 48000.0n 3.3V 48030.0n 0.0V)
* PWL waveform for B
VB B 0 PWL(0.0n 0.0V 30.0n 0.0V 200.0n 0.0V 230.0n 0.0V 400.0n 0.0V 430.0n 0.0V 600.0n 0.0V 630.0n 3.3V 800.0n 3.3V 830.0n 0.0V 1000.0n 0.0V 1030.0n 3.3V 1200.0n 3.3V 1230.0n 0.0V 1400.0n 0.0V 1430.0n 0.0V 1600.0n 0.0V 1630.0n 0.0V 1800.0n 0.0V 1830.0n 0.0V 2000.0n 0.0V 2030.0n 0.0V 2200.0n 0.0V 2230.0n 3.3V 2400.0n 3.3V 2430.0n 0.0V 2600.0n 0.0V 2630.0n 3.3V 2800.0n 3.3V 2830.0n 0.0V 3000.0n 0.0V 3030.0n 0.0V 3200.0n 0.0V 3230.0n 0.0V 3400.0n 0.0V 3430.0n 0.0V 3600.0n 0.0V 3630.0n 0.0V 3800.0n 0.0V 3830.0n 3.3V 4000.0n 3.3V 4030.0n 0.0V 4200.0n 0.0V 4230.0n 3.3V 4400.0n 3.3V 4430.0n 0.0V 4600.0n 0.0V 4630.0n 0.0V 4800.0n 0.0V 4830.0n 0.0V 5000.0n 0.0V 5030.0n 0.0V 5200.0n 0.0V 5230.0n 0.0V 5400.0n 0.0V 5430.0n 3.3V 5600.0n 3.3V 5630.0n 0.0V 5800.0n 0.0V 5830.0n 3.3V 6000.0n 3.3V 6030.0n 0.0V 6200.0n 0.0V 6230.0n 3.3V 6400.0n 3.3V 6430.0n 0.0V 6600.0n 0.0V 6630.0n 3.3V 6800.0n 3.3V 6830.0n 0.0V 7000.0n 0.0V 7030.0n 0.0V 7200.0n 0.0V 7230.0n 0.0V 7400.0n 0.0V 7430.0n 0.0V 7600.0n 0.0V 7630.0n 0.0V 7800.0n 0.0V 7830.0n 3.3V 8000.0n 3.3V 8030.0n 0.0V 8200.0n 0.0V 8230.0n 3.3V 8400.0n 3.3V 8430.0n 0.0V 8600.0n 0.0V 8630.0n 0.0V 8800.0n 0.0V 8830.0n 0.0V 9000.0n 0.0V 9030.0n 0.0V 9200.0n 0.0V 9230.0n 0.0V 9400.0n 0.0V 9430.0n 3.3V 9600.0n 3.3V 9630.0n 0.0V 9800.0n 0.0V 9830.0n 3.3V 10000.0n 3.3V 10030.0n 0.0V 10200.0n 0.0V 10230.0n 0.0V 10400.0n 0.0V 10430.0n 0.0V 10600.0n 0.0V 10630.0n 0.0V 10800.0n 0.0V 10830.0n 0.0V 11000.0n 0.0V 11030.0n 3.3V 11200.0n 3.3V 11230.0n 0.0V 11400.0n 0.0V 11430.0n 3.3V 11600.0n 3.3V 11630.0n 3.3V 11800.0n 3.3V 11830.0n 3.3V 12000.0n 3.3V 12030.0n 3.3V 12200.0n 3.3V 12230.0n 0.0V 12400.0n 0.0V 12430.0n 3.3V 12600.0n 3.3V 12630.0n 0.0V 12800.0n 0.0V 12830.0n 3.3V 13000.0n 3.3V 13030.0n 3.3V 13200.0n 3.3V 13230.0n 3.3V 13400.0n 3.3V 13430.0n 3.3V 13600.0n 3.3V 13630.0n 3.3V 13800.0n 3.3V 13830.0n 0.0V 14000.0n 0.0V 14030.0n 3.3V 14200.0n 3.3V 14230.0n 0.0V 14400.0n 0.0V 14430.0n 3.3V 14600.0n 3.3V 14630.0n 3.3V 14800.0n 3.3V 14830.0n 3.3V 15000.0n 3.3V 15030.0n 3.3V 15200.0n 3.3V 15230.0n 3.3V 15400.0n 3.3V 15430.0n 0.0V 15600.0n 0.0V 15630.0n 3.3V 15800.0n 3.3V 15830.0n 0.0V 16000.0n 0.0V 16030.0n 3.3V 16200.0n 3.3V 16230.0n 3.3V 16400.0n 3.3V 16430.0n 3.3V 16600.0n 3.3V 16630.0n 3.3V 16800.0n 3.3V 16830.0n 3.3V 17000.0n 3.3V 17030.0n 0.0V 17200.0n 0.0V 17230.0n 3.3V 17400.0n 3.3V 17430.0n 0.0V 17600.0n 0.0V 17630.0n 3.3V 17800.0n 3.3V 17830.0n 3.3V 18000.0n 3.3V 18030.0n 3.3V 18200.0n 3.3V 18230.0n 3.3V 18400.0n 3.3V 18430.0n 3.3V 18600.0n 3.3V 18630.0n 0.0V 18800.0n 0.0V 18830.0n 3.3V 19000.0n 3.3V 19030.0n 0.0V 19200.0n 0.0V 19230.0n 3.3V 19400.0n 3.3V 19430.0n 3.3V 19600.0n 3.3V 19630.0n 3.3V 19800.0n 3.3V 19830.0n 3.3V 20000.0n 3.3V 20030.0n 3.3V 20200.0n 3.3V 20230.0n 0.0V 20400.0n 0.0V 20430.0n 3.3V 20600.0n 3.3V 20630.0n 0.0V 20800.0n 0.0V 20830.0n 3.3V 21000.0n 3.3V 21030.0n 3.3V 21200.0n 3.3V 21230.0n 3.3V 21400.0n 3.3V 21430.0n 3.3V 21600.0n 3.3V 21630.0n 0.0V 21800.0n 0.0V 21830.0n 0.0V 22000.0n 0.0V 22030.0n 0.0V 22200.0n 0.0V 22230.0n 3.3V 22400.0n 3.3V 22430.0n 0.0V 22600.0n 0.0V 22630.0n 3.3V 22800.0n 3.3V 22830.0n 0.0V 23000.0n 0.0V 23030.0n 0.0V 23200.0n 0.0V 23230.0n 0.0V 23400.0n 0.0V 23430.0n 0.0V 23600.0n 0.0V 23630.0n 0.0V 23800.0n 0.0V 23830.0n 3.3V 24000.0n 3.3V 24030.0n 0.0V 24200.0n 0.0V 24230.0n 3.3V 24400.0n 3.3V 24430.0n 0.0V 24600.0n 0.0V 24630.0n 0.0V 24800.0n 0.0V 24830.0n 0.0V 25000.0n 0.0V 25030.0n 0.0V 25200.0n 0.0V 25230.0n 0.0V 25400.0n 0.0V 25430.0n 3.3V 25600.0n 3.3V 25630.0n 0.0V 25800.0n 0.0V 25830.0n 3.3V 26000.0n 3.3V 26030.0n 0.0V 26200.0n 0.0V 26230.0n 3.3V 26400.0n 3.3V 26430.0n 0.0V 26600.0n 0.0V 26630.0n 3.3V 26800.0n 3.3V 26830.0n 0.0V 27000.0n 0.0V 27030.0n 0.0V 27200.0n 0.0V 27230.0n 0.0V 27400.0n 0.0V 27430.0n 0.0V 27600.0n 0.0V 27630.0n 0.0V 27800.0n 0.0V 27830.0n 3.3V 28000.0n 3.3V 28030.0n 0.0V 28200.0n 0.0V 28230.0n 3.3V 28400.0n 3.3V 28430.0n 0.0V 28600.0n 0.0V 28630.0n 0.0V 28800.0n 0.0V 28830.0n 0.0V 29000.0n 0.0V 29030.0n 0.0V 29200.0n 0.0V 29230.0n 0.0V 29400.0n 0.0V 29430.0n 3.3V 29600.0n 3.3V 29630.0n 0.0V 29800.0n 0.0V 29830.0n 3.3V 30000.0n 3.3V 30030.0n 3.3V 30200.0n 3.3V 30230.0n 3.3V 30400.0n 3.3V 30430.0n 3.3V 30600.0n 3.3V 30630.0n 0.0V 30800.0n 0.0V 30830.0n 3.3V 31000.0n 3.3V 31030.0n 0.0V 31200.0n 0.0V 31230.0n 3.3V 31400.0n 3.3V 31430.0n 3.3V 31600.0n 3.3V 31630.0n 3.3V 31800.0n 3.3V 31830.0n 3.3V 32000.0n 3.3V 32030.0n 3.3V 32200.0n 3.3V 32230.0n 0.0V 32400.0n 0.0V 32430.0n 3.3V 32600.0n 3.3V 32630.0n 0.0V 32800.0n 0.0V 32830.0n 3.3V 33000.0n 3.3V 33030.0n 3.3V 33200.0n 3.3V 33230.0n 3.3V 33400.0n 3.3V 33430.0n 3.3V 33600.0n 3.3V 33630.0n 3.3V 33800.0n 3.3V 33830.0n 0.0V 34000.0n 0.0V 34030.0n 3.3V 34200.0n 3.3V 34230.0n 0.0V 34400.0n 0.0V 34430.0n 3.3V 34600.0n 3.3V 34630.0n 3.3V 34800.0n 3.3V 34830.0n 3.3V 35000.0n 3.3V 35030.0n 3.3V 35200.0n 3.3V 35230.0n 3.3V 35400.0n 3.3V 35430.0n 0.0V 35600.0n 0.0V 35630.0n 3.3V 35800.0n 3.3V 35830.0n 0.0V 36000.0n 0.0V 36030.0n 3.3V 36200.0n 3.3V 36230.0n 3.3V 36400.0n 3.3V 36430.0n 3.3V 36600.0n 3.3V 36630.0n 3.3V 36800.0n 3.3V 36830.0n 0.0V 37000.0n 0.0V 37030.0n 0.0V 37200.0n 0.0V 37230.0n 0.0V 37400.0n 0.0V 37430.0n 3.3V 37600.0n 3.3V 37630.0n 0.0V 37800.0n 0.0V 37830.0n 3.3V 38000.0n 3.3V 38030.0n 0.0V 38200.0n 0.0V 38230.0n 0.0V 38400.0n 0.0V 38430.0n 0.0V 38600.0n 0.0V 38630.0n 0.0V 38800.0n 0.0V 38830.0n 0.0V 39000.0n 0.0V 39030.0n 3.3V 39200.0n 3.3V 39230.0n 0.0V 39400.0n 0.0V 39430.0n 3.3V 39600.0n 3.3V 39630.0n 0.0V 39800.0n 0.0V 39830.0n 3.3V 40000.0n 3.3V 40030.0n 0.0V 40200.0n 0.0V 40230.0n 3.3V 40400.0n 3.3V 40430.0n 0.0V 40600.0n 0.0V 40630.0n 0.0V 40800.0n 0.0V 40830.0n 0.0V 41000.0n 0.0V 41030.0n 0.0V 41200.0n 0.0V 41230.0n 0.0V 41400.0n 0.0V 41430.0n 3.3V 41600.0n 3.3V 41630.0n 0.0V 41800.0n 0.0V 41830.0n 3.3V 42000.0n 3.3V 42030.0n 3.3V 42200.0n 3.3V 42230.0n 3.3V 42400.0n 3.3V 42430.0n 3.3V 42600.0n 3.3V 42630.0n 0.0V 42800.0n 0.0V 42830.0n 3.3V 43000.0n 3.3V 43030.0n 0.0V 43200.0n 0.0V 43230.0n 3.3V 43400.0n 3.3V 43430.0n 3.3V 43600.0n 3.3V 43630.0n 3.3V 43800.0n 3.3V 43830.0n 3.3V 44000.0n 3.3V 44030.0n 3.3V 44200.0n 3.3V 44230.0n 0.0V 44400.0n 0.0V 44430.0n 3.3V 44600.0n 3.3V 44630.0n 0.0V 44800.0n 0.0V 44830.0n 3.3V 45000.0n 3.3V 45030.0n 3.3V 45200.0n 3.3V 45230.0n 3.3V 45400.0n 3.3V 45430.0n 3.3V 45600.0n 3.3V 45630.0n 0.0V 45800.0n 0.0V 45830.0n 0.0V 46000.0n 0.0V 46030.0n 0.0V 46200.0n 0.0V 46230.0n 3.3V 46400.0n 3.3V 46430.0n 0.0V 46600.0n 0.0V 46630.0n 3.3V 46800.0n 3.3V 46830.0n 0.0V 47000.0n 0.0V 47030.0n 3.3V 47200.0n 3.3V 47230.0n 0.0V 47400.0n 0.0V 47430.0n 3.3V 47600.0n 3.3V 47630.0n 3.3V 47800.0n 3.3V 47830.0n 3.3V 48000.0n 3.3V 48030.0n 0.0V)
* PWL waveform for C
VC C 0 PWL(0.0n 0.0V 30.0n 0.0V 200.0n 0.0V 230.0n 0.0V 400.0n 0.0V 430.0n 0.0V 600.0n 0.0V 630.0n 0.0V 800.0n 0.0V 830.0n 0.0V 1000.0n 0.0V 1030.0n 0.0V 1200.0n 0.0V 1230.0n 0.0V 1400.0n 0.0V 1430.0n 3.3V 1600.0n 3.3V 1630.0n 0.0V 1800.0n 0.0V 1830.0n 3.3V 2000.0n 3.3V 2030.0n 0.0V 2200.0n 0.0V 2230.0n 3.3V 2400.0n 3.3V 2430.0n 0.0V 2600.0n 0.0V 2630.0n 3.3V 2800.0n 3.3V 2830.0n 0.0V 3000.0n 0.0V 3030.0n 0.0V 3200.0n 0.0V 3230.0n 0.0V 3400.0n 0.0V 3430.0n 0.0V 3600.0n 0.0V 3630.0n 0.0V 3800.0n 0.0V 3830.0n 0.0V 4000.0n 0.0V 4030.0n 0.0V 4200.0n 0.0V 4230.0n 0.0V 4400.0n 0.0V 4430.0n 0.0V 4600.0n 0.0V 4630.0n 3.3V 4800.0n 3.3V 4830.0n 0.0V 5000.0n 0.0V 5030.0n 3.3V 5200.0n 3.3V 5230.0n 0.0V 5400.0n 0.0V 5430.0n 3.3V 5600.0n 3.3V 5630.0n 0.0V 5800.0n 0.0V 5830.0n 3.3V 6000.0n 3.3V 6030.0n 0.0V 6200.0n 0.0V 6230.0n 0.0V 6400.0n 0.0V 6430.0n 0.0V 6600.0n 0.0V 6630.0n 0.0V 6800.0n 0.0V 6830.0n 0.0V 7000.0n 0.0V 7030.0n 3.3V 7200.0n 3.3V 7230.0n 0.0V 7400.0n 0.0V 7430.0n 3.3V 7600.0n 3.3V 7630.0n 0.0V 7800.0n 0.0V 7830.0n 3.3V 8000.0n 3.3V 8030.0n 0.0V 8200.0n 0.0V 8230.0n 3.3V 8400.0n 3.3V 8430.0n 0.0V 8600.0n 0.0V 8630.0n 0.0V 8800.0n 0.0V 8830.0n 0.0V 9000.0n 0.0V 9030.0n 0.0V 9200.0n 0.0V 9230.0n 0.0V 9400.0n 0.0V 9430.0n 0.0V 9600.0n 0.0V 9630.0n 0.0V 9800.0n 0.0V 9830.0n 0.0V 10000.0n 0.0V 10030.0n 0.0V 10200.0n 0.0V 10230.0n 3.3V 10400.0n 3.3V 10430.0n 0.0V 10600.0n 0.0V 10630.0n 3.3V 10800.0n 3.3V 10830.0n 0.0V 11000.0n 0.0V 11030.0n 3.3V 11200.0n 3.3V 11230.0n 0.0V 11400.0n 0.0V 11430.0n 3.3V 11600.0n 3.3V 11630.0n 0.0V 11800.0n 0.0V 11830.0n 0.0V 12000.0n 0.0V 12030.0n 0.0V 12200.0n 0.0V 12230.0n 3.3V 12400.0n 3.3V 12430.0n 0.0V 12600.0n 0.0V 12630.0n 3.3V 12800.0n 3.3V 12830.0n 0.0V 13000.0n 0.0V 13030.0n 3.3V 13200.0n 3.3V 13230.0n 0.0V 13400.0n 0.0V 13430.0n 3.3V 13600.0n 3.3V 13630.0n 0.0V 13800.0n 0.0V 13830.0n 0.0V 14000.0n 0.0V 14030.0n 0.0V 14200.0n 0.0V 14230.0n 0.0V 14400.0n 0.0V 14430.0n 0.0V 14600.0n 0.0V 14630.0n 0.0V 14800.0n 0.0V 14830.0n 0.0V 15000.0n 0.0V 15030.0n 0.0V 15200.0n 0.0V 15230.0n 0.0V 15400.0n 0.0V 15430.0n 3.3V 15600.0n 3.3V 15630.0n 0.0V 15800.0n 0.0V 15830.0n 3.3V 16000.0n 3.3V 16030.0n 0.0V 16200.0n 0.0V 16230.0n 3.3V 16400.0n 3.3V 16430.0n 0.0V 16600.0n 0.0V 16630.0n 3.3V 16800.0n 3.3V 16830.0n 0.0V 17000.0n 0.0V 17030.0n 3.3V 17200.0n 3.3V 17230.0n 0.0V 17400.0n 0.0V 17430.0n 3.3V 17600.0n 3.3V 17630.0n 0.0V 17800.0n 0.0V 17830.0n 3.3V 18000.0n 3.3V 18030.0n 0.0V 18200.0n 0.0V 18230.0n 3.3V 18400.0n 3.3V 18430.0n 0.0V 18600.0n 0.0V 18630.0n 0.0V 18800.0n 0.0V 18830.0n 0.0V 19000.0n 0.0V 19030.0n 0.0V 19200.0n 0.0V 19230.0n 0.0V 19400.0n 0.0V 19430.0n 0.0V 19600.0n 0.0V 19630.0n 0.0V 19800.0n 0.0V 19830.0n 0.0V 20000.0n 0.0V 20030.0n 0.0V 20200.0n 0.0V 20230.0n 3.3V 20400.0n 3.3V 20430.0n 0.0V 20600.0n 0.0V 20630.0n 3.3V 20800.0n 3.3V 20830.0n 0.0V 21000.0n 0.0V 21030.0n 3.3V 21200.0n 3.3V 21230.0n 0.0V 21400.0n 0.0V 21430.0n 3.3V 21600.0n 3.3V 21630.0n 3.3V 21800.0n 3.3V 21830.0n 3.3V 22000.0n 3.3V 22030.0n 3.3V 22200.0n 3.3V 22230.0n 3.3V 22400.0n 3.3V 22430.0n 3.3V 22600.0n 3.3V 22630.0n 3.3V 22800.0n 3.3V 22830.0n 3.3V 23000.0n 3.3V 23030.0n 0.0V 23200.0n 0.0V 23230.0n 3.3V 23400.0n 3.3V 23430.0n 0.0V 23600.0n 0.0V 23630.0n 3.3V 23800.0n 3.3V 23830.0n 0.0V 24000.0n 0.0V 24030.0n 3.3V 24200.0n 3.3V 24230.0n 0.0V 24400.0n 0.0V 24430.0n 3.3V 24600.0n 3.3V 24630.0n 3.3V 24800.0n 3.3V 24830.0n 3.3V 25000.0n 3.3V 25030.0n 3.3V 25200.0n 3.3V 25230.0n 3.3V 25400.0n 3.3V 25430.0n 3.3V 25600.0n 3.3V 25630.0n 3.3V 25800.0n 3.3V 25830.0n 3.3V 26000.0n 3.3V 26030.0n 3.3V 26200.0n 3.3V 26230.0n 3.3V 26400.0n 3.3V 26430.0n 3.3V 26600.0n 3.3V 26630.0n 3.3V 26800.0n 3.3V 26830.0n 3.3V 27000.0n 3.3V 27030.0n 0.0V 27200.0n 0.0V 27230.0n 3.3V 27400.0n 3.3V 27430.0n 0.0V 27600.0n 0.0V 27630.0n 3.3V 27800.0n 3.3V 27830.0n 0.0V 28000.0n 0.0V 28030.0n 3.3V 28200.0n 3.3V 28230.0n 0.0V 28400.0n 0.0V 28430.0n 3.3V 28600.0n 3.3V 28630.0n 3.3V 28800.0n 3.3V 28830.0n 3.3V 29000.0n 3.3V 29030.0n 3.3V 29200.0n 3.3V 29230.0n 3.3V 29400.0n 3.3V 29430.0n 3.3V 29600.0n 3.3V 29630.0n 3.3V 29800.0n 3.3V 29830.0n 3.3V 30000.0n 3.3V 30030.0n 3.3V 30200.0n 3.3V 30230.0n 3.3V 30400.0n 3.3V 30430.0n 3.3V 30600.0n 3.3V 30630.0n 0.0V 30800.0n 0.0V 30830.0n 3.3V 31000.0n 3.3V 31030.0n 0.0V 31200.0n 0.0V 31230.0n 3.3V 31400.0n 3.3V 31430.0n 0.0V 31600.0n 0.0V 31630.0n 3.3V 31800.0n 3.3V 31830.0n 0.0V 32000.0n 0.0V 32030.0n 3.3V 32200.0n 3.3V 32230.0n 3.3V 32400.0n 3.3V 32430.0n 3.3V 32600.0n 3.3V 32630.0n 3.3V 32800.0n 3.3V 32830.0n 3.3V 33000.0n 3.3V 33030.0n 3.3V 33200.0n 3.3V 33230.0n 3.3V 33400.0n 3.3V 33430.0n 3.3V 33600.0n 3.3V 33630.0n 3.3V 33800.0n 3.3V 33830.0n 0.0V 34000.0n 0.0V 34030.0n 3.3V 34200.0n 3.3V 34230.0n 0.0V 34400.0n 0.0V 34430.0n 3.3V 34600.0n 3.3V 34630.0n 0.0V 34800.0n 0.0V 34830.0n 3.3V 35000.0n 3.3V 35030.0n 0.0V 35200.0n 0.0V 35230.0n 3.3V 35400.0n 3.3V 35430.0n 3.3V 35600.0n 3.3V 35630.0n 3.3V 35800.0n 3.3V 35830.0n 3.3V 36000.0n 3.3V 36030.0n 3.3V 36200.0n 3.3V 36230.0n 3.3V 36400.0n 3.3V 36430.0n 3.3V 36600.0n 3.3V 36630.0n 3.3V 36800.0n 3.3V 36830.0n 0.0V 37000.0n 0.0V 37030.0n 0.0V 37200.0n 0.0V 37230.0n 0.0V 37400.0n 0.0V 37430.0n 0.0V 37600.0n 0.0V 37630.0n 0.0V 37800.0n 0.0V 37830.0n 0.0V 38000.0n 0.0V 38030.0n 0.0V 38200.0n 0.0V 38230.0n 3.3V 38400.0n 3.3V 38430.0n 0.0V 38600.0n 0.0V 38630.0n 3.3V 38800.0n 3.3V 38830.0n 0.0V 39000.0n 0.0V 39030.0n 3.3V 39200.0n 3.3V 39230.0n 0.0V 39400.0n 0.0V 39430.0n 3.3V 39600.0n 3.3V 39630.0n 0.0V 39800.0n 0.0V 39830.0n 0.0V 40000.0n 0.0V 40030.0n 0.0V 40200.0n 0.0V 40230.0n 0.0V 40400.0n 0.0V 40430.0n 0.0V 40600.0n 0.0V 40630.0n 3.3V 40800.0n 3.3V 40830.0n 0.0V 41000.0n 0.0V 41030.0n 3.3V 41200.0n 3.3V 41230.0n 0.0V 41400.0n 0.0V 41430.0n 3.3V 41600.0n 3.3V 41630.0n 0.0V 41800.0n 0.0V 41830.0n 3.3V 42000.0n 3.3V 42030.0n 0.0V 42200.0n 0.0V 42230.0n 0.0V 42400.0n 0.0V 42430.0n 0.0V 42600.0n 0.0V 42630.0n 3.3V 42800.0n 3.3V 42830.0n 0.0V 43000.0n 0.0V 43030.0n 3.3V 43200.0n 3.3V 43230.0n 0.0V 43400.0n 0.0V 43430.0n 3.3V 43600.0n 3.3V 43630.0n 0.0V 43800.0n 0.0V 43830.0n 3.3V 44000.0n 3.3V 44030.0n 0.0V 44200.0n 0.0V 44230.0n 3.3V 44400.0n 3.3V 44430.0n 0.0V 44600.0n 0.0V 44630.0n 3.3V 44800.0n 3.3V 44830.0n 0.0V 45000.0n 0.0V 45030.0n 3.3V 45200.0n 3.3V 45230.0n 0.0V 45400.0n 0.0V 45430.0n 3.3V 45600.0n 3.3V 45630.0n 3.3V 45800.0n 3.3V 45830.0n 3.3V 46000.0n 3.3V 46030.0n 3.3V 46200.0n 3.3V 46230.0n 3.3V 46400.0n 3.3V 46430.0n 3.3V 46600.0n 3.3V 46630.0n 3.3V 46800.0n 3.3V 46830.0n 3.3V 47000.0n 3.3V 47030.0n 3.3V 47200.0n 3.3V 47230.0n 3.3V 47400.0n 3.3V 47430.0n 3.3V 47600.0n 3.3V 47630.0n 3.3V 47800.0n 3.3V 47830.0n 3.3V 48000.0n 3.3V 48030.0n 0.0V)
* PWL waveform for D
VD D 0 PWL(0.0n 0.0V 30.0n 0.0V 200.0n 0.0V 230.0n 0.0V 400.0n 0.0V 430.0n 0.0V 600.0n 0.0V 630.0n 0.0V 800.0n 0.0V 830.0n 0.0V 1000.0n 0.0V 1030.0n 0.0V 1200.0n 0.0V 1230.0n 0.0V 1400.0n 0.0V 1430.0n 0.0V 1600.0n 0.0V 1630.0n 0.0V 1800.0n 0.0V 1830.0n 0.0V 2000.0n 0.0V 2030.0n 0.0V 2200.0n 0.0V 2230.0n 0.0V 2400.0n 0.0V 2430.0n 0.0V 2600.0n 0.0V 2630.0n 0.0V 2800.0n 0.0V 2830.0n 0.0V 3000.0n 0.0V 3030.0n 3.3V 3200.0n 3.3V 3230.0n 0.0V 3400.0n 0.0V 3430.0n 3.3V 3600.0n 3.3V 3630.0n 0.0V 3800.0n 0.0V 3830.0n 3.3V 4000.0n 3.3V 4030.0n 0.0V 4200.0n 0.0V 4230.0n 3.3V 4400.0n 3.3V 4430.0n 0.0V 4600.0n 0.0V 4630.0n 3.3V 4800.0n 3.3V 4830.0n 0.0V 5000.0n 0.0V 5030.0n 3.3V 5200.0n 3.3V 5230.0n 0.0V 5400.0n 0.0V 5430.0n 3.3V 5600.0n 3.3V 5630.0n 0.0V 5800.0n 0.0V 5830.0n 3.3V 6000.0n 3.3V 6030.0n 0.0V 6200.0n 0.0V 6230.0n 0.0V 6400.0n 0.0V 6430.0n 0.0V 6600.0n 0.0V 6630.0n 0.0V 6800.0n 0.0V 6830.0n 0.0V 7000.0n 0.0V 7030.0n 0.0V 7200.0n 0.0V 7230.0n 0.0V 7400.0n 0.0V 7430.0n 0.0V 7600.0n 0.0V 7630.0n 0.0V 7800.0n 0.0V 7830.0n 0.0V 8000.0n 0.0V 8030.0n 0.0V 8200.0n 0.0V 8230.0n 0.0V 8400.0n 0.0V 8430.0n 0.0V 8600.0n 0.0V 8630.0n 3.3V 8800.0n 3.3V 8830.0n 0.0V 9000.0n 0.0V 9030.0n 3.3V 9200.0n 3.3V 9230.0n 0.0V 9400.0n 0.0V 9430.0n 3.3V 9600.0n 3.3V 9630.0n 0.0V 9800.0n 0.0V 9830.0n 3.3V 10000.0n 3.3V 10030.0n 0.0V 10200.0n 0.0V 10230.0n 3.3V 10400.0n 3.3V 10430.0n 0.0V 10600.0n 0.0V 10630.0n 3.3V 10800.0n 3.3V 10830.0n 0.0V 11000.0n 0.0V 11030.0n 3.3V 11200.0n 3.3V 11230.0n 0.0V 11400.0n 0.0V 11430.0n 3.3V 11600.0n 3.3V 11630.0n 0.0V 11800.0n 0.0V 11830.0n 0.0V 12000.0n 0.0V 12030.0n 0.0V 12200.0n 0.0V 12230.0n 0.0V 12400.0n 0.0V 12430.0n 0.0V 12600.0n 0.0V 12630.0n 0.0V 12800.0n 0.0V 12830.0n 0.0V 13000.0n 0.0V 13030.0n 0.0V 13200.0n 0.0V 13230.0n 0.0V 13400.0n 0.0V 13430.0n 0.0V 13600.0n 0.0V 13630.0n 0.0V 13800.0n 0.0V 13830.0n 3.3V 14000.0n 3.3V 14030.0n 0.0V 14200.0n 0.0V 14230.0n 3.3V 14400.0n 3.3V 14430.0n 0.0V 14600.0n 0.0V 14630.0n 3.3V 14800.0n 3.3V 14830.0n 0.0V 15000.0n 0.0V 15030.0n 3.3V 15200.0n 3.3V 15230.0n 0.0V 15400.0n 0.0V 15430.0n 3.3V 15600.0n 3.3V 15630.0n 0.0V 15800.0n 0.0V 15830.0n 3.3V 16000.0n 3.3V 16030.0n 0.0V 16200.0n 0.0V 16230.0n 3.3V 16400.0n 3.3V 16430.0n 0.0V 16600.0n 0.0V 16630.0n 3.3V 16800.0n 3.3V 16830.0n 0.0V 17000.0n 0.0V 17030.0n 0.0V 17200.0n 0.0V 17230.0n 0.0V 17400.0n 0.0V 17430.0n 0.0V 17600.0n 0.0V 17630.0n 0.0V 17800.0n 0.0V 17830.0n 0.0V 18000.0n 0.0V 18030.0n 0.0V 18200.0n 0.0V 18230.0n 0.0V 18400.0n 0.0V 18430.0n 0.0V 18600.0n 0.0V 18630.0n 3.3V 18800.0n 3.3V 18830.0n 0.0V 19000.0n 0.0V 19030.0n 3.3V 19200.0n 3.3V 19230.0n 0.0V 19400.0n 0.0V 19430.0n 3.3V 19600.0n 3.3V 19630.0n 0.0V 19800.0n 0.0V 19830.0n 3.3V 20000.0n 3.3V 20030.0n 0.0V 20200.0n 0.0V 20230.0n 3.3V 20400.0n 3.3V 20430.0n 0.0V 20600.0n 0.0V 20630.0n 3.3V 20800.0n 3.3V 20830.0n 0.0V 21000.0n 0.0V 21030.0n 3.3V 21200.0n 3.3V 21230.0n 0.0V 21400.0n 0.0V 21430.0n 3.3V 21600.0n 3.3V 21630.0n 0.0V 21800.0n 0.0V 21830.0n 0.0V 22000.0n 0.0V 22030.0n 0.0V 22200.0n 0.0V 22230.0n 0.0V 22400.0n 0.0V 22430.0n 0.0V 22600.0n 0.0V 22630.0n 0.0V 22800.0n 0.0V 22830.0n 0.0V 23000.0n 0.0V 23030.0n 3.3V 23200.0n 3.3V 23230.0n 0.0V 23400.0n 0.0V 23430.0n 3.3V 23600.0n 3.3V 23630.0n 0.0V 23800.0n 0.0V 23830.0n 3.3V 24000.0n 3.3V 24030.0n 0.0V 24200.0n 0.0V 24230.0n 3.3V 24400.0n 3.3V 24430.0n 0.0V 24600.0n 0.0V 24630.0n 3.3V 24800.0n 3.3V 24830.0n 0.0V 25000.0n 0.0V 25030.0n 3.3V 25200.0n 3.3V 25230.0n 0.0V 25400.0n 0.0V 25430.0n 3.3V 25600.0n 3.3V 25630.0n 0.0V 25800.0n 0.0V 25830.0n 3.3V 26000.0n 3.3V 26030.0n 0.0V 26200.0n 0.0V 26230.0n 0.0V 26400.0n 0.0V 26430.0n 0.0V 26600.0n 0.0V 26630.0n 0.0V 26800.0n 0.0V 26830.0n 0.0V 27000.0n 0.0V 27030.0n 3.3V 27200.0n 3.3V 27230.0n 0.0V 27400.0n 0.0V 27430.0n 3.3V 27600.0n 3.3V 27630.0n 0.0V 27800.0n 0.0V 27830.0n 3.3V 28000.0n 3.3V 28030.0n 0.0V 28200.0n 0.0V 28230.0n 3.3V 28400.0n 3.3V 28430.0n 0.0V 28600.0n 0.0V 28630.0n 3.3V 28800.0n 3.3V 28830.0n 0.0V 29000.0n 0.0V 29030.0n 3.3V 29200.0n 3.3V 29230.0n 0.0V 29400.0n 0.0V 29430.0n 3.3V 29600.0n 3.3V 29630.0n 0.0V 29800.0n 0.0V 29830.0n 3.3V 30000.0n 3.3V 30030.0n 0.0V 30200.0n 0.0V 30230.0n 0.0V 30400.0n 0.0V 30430.0n 0.0V 30600.0n 0.0V 30630.0n 3.3V 30800.0n 3.3V 30830.0n 0.0V 31000.0n 0.0V 31030.0n 3.3V 31200.0n 3.3V 31230.0n 0.0V 31400.0n 0.0V 31430.0n 3.3V 31600.0n 3.3V 31630.0n 0.0V 31800.0n 0.0V 31830.0n 3.3V 32000.0n 3.3V 32030.0n 0.0V 32200.0n 0.0V 32230.0n 3.3V 32400.0n 3.3V 32430.0n 0.0V 32600.0n 0.0V 32630.0n 3.3V 32800.0n 3.3V 32830.0n 0.0V 33000.0n 0.0V 33030.0n 3.3V 33200.0n 3.3V 33230.0n 0.0V 33400.0n 0.0V 33430.0n 3.3V 33600.0n 3.3V 33630.0n 0.0V 33800.0n 0.0V 33830.0n 3.3V 34000.0n 3.3V 34030.0n 0.0V 34200.0n 0.0V 34230.0n 3.3V 34400.0n 3.3V 34430.0n 0.0V 34600.0n 0.0V 34630.0n 3.3V 34800.0n 3.3V 34830.0n 0.0V 35000.0n 0.0V 35030.0n 3.3V 35200.0n 3.3V 35230.0n 0.0V 35400.0n 0.0V 35430.0n 3.3V 35600.0n 3.3V 35630.0n 0.0V 35800.0n 0.0V 35830.0n 3.3V 36000.0n 3.3V 36030.0n 0.0V 36200.0n 0.0V 36230.0n 3.3V 36400.0n 3.3V 36430.0n 0.0V 36600.0n 0.0V 36630.0n 3.3V 36800.0n 3.3V 36830.0n 3.3V 37000.0n 3.3V 37030.0n 3.3V 37200.0n 3.3V 37230.0n 3.3V 37400.0n 3.3V 37430.0n 3.3V 37600.0n 3.3V 37630.0n 3.3V 37800.0n 3.3V 37830.0n 3.3V 38000.0n 3.3V 38030.0n 3.3V 38200.0n 3.3V 38230.0n 3.3V 38400.0n 3.3V 38430.0n 3.3V 38600.0n 3.3V 38630.0n 3.3V 38800.0n 3.3V 38830.0n 3.3V 39000.0n 3.3V 39030.0n 3.3V 39200.0n 3.3V 39230.0n 3.3V 39400.0n 3.3V 39430.0n 3.3V 39600.0n 3.3V 39630.0n 3.3V 39800.0n 3.3V 39830.0n 3.3V 40000.0n 3.3V 40030.0n 3.3V 40200.0n 3.3V 40230.0n 3.3V 40400.0n 3.3V 40430.0n 3.3V 40600.0n 3.3V 40630.0n 3.3V 40800.0n 3.3V 40830.0n 3.3V 41000.0n 3.3V 41030.0n 3.3V 41200.0n 3.3V 41230.0n 3.3V 41400.0n 3.3V 41430.0n 3.3V 41600.0n 3.3V 41630.0n 3.3V 41800.0n 3.3V 41830.0n 3.3V 42000.0n 3.3V 42030.0n 3.3V 42200.0n 3.3V 42230.0n 3.3V 42400.0n 3.3V 42430.0n 3.3V 42600.0n 3.3V 42630.0n 3.3V 42800.0n 3.3V 42830.0n 3.3V 43000.0n 3.3V 43030.0n 3.3V 43200.0n 3.3V 43230.0n 3.3V 43400.0n 3.3V 43430.0n 3.3V 43600.0n 3.3V 43630.0n 3.3V 43800.0n 3.3V 43830.0n 3.3V 44000.0n 3.3V 44030.0n 3.3V 44200.0n 3.3V 44230.0n 3.3V 44400.0n 3.3V 44430.0n 3.3V 44600.0n 3.3V 44630.0n 3.3V 44800.0n 3.3V 44830.0n 3.3V 45000.0n 3.3V 45030.0n 3.3V 45200.0n 3.3V 45230.0n 3.3V 45400.0n 3.3V 45430.0n 3.3V 45600.0n 3.3V 45630.0n 3.3V 45800.0n 3.3V 45830.0n 3.3V 46000.0n 3.3V 46030.0n 3.3V 46200.0n 3.3V 46230.0n 3.3V 46400.0n 3.3V 46430.0n 3.3V 46600.0n 3.3V 46630.0n 3.3V 46800.0n 3.3V 46830.0n 3.3V 47000.0n 3.3V 47030.0n 3.3V 47200.0n 3.3V 47230.0n 3.3V 47400.0n 3.3V 47430.0n 3.3V 47600.0n 3.3V 47630.0n 3.3V 47800.0n 3.3V 47830.0n 3.3V 48000.0n 3.3V 48030.0n 0.0V)
