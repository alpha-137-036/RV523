* PWL waveform for EN
* VEN EN 0 PWL(0.0n 0.0V 200.0n 0.0V 230.0n 3.3V 370.0n 3.3V 400n 0.0V 600.0n 0V 630n 3.3V 770.0n 3.3V 800n 0.0V 1000.0n 0V 1030n 3.3V)
* PWL waveform for nEN (non-overlapping)
* VnEN nEN 0 PWL(0.0n 3.3V 170.0n 3.3V 200.0n 0.0V 400.0n 0.0V 430n 3.3V 570.0n 3.3V 600n 0V 800.0n 0V 830n 3.3V 970.0n 3.3V 1000n 0V)

* PWL waveform for EN
VEN EN 0 PWL(0.0n 0.0V 200.0n 0.0V 230.0n 3.3V 400.0n 3.3V 430n 0.0V 600.0n 0V 630n 3.3V 800.0n 3.3V 830n 0.0V 1000.0n 0V 1030n 3.3V)
* PWL waveform for nEN (non-overlapping)
VnEN nEN 0 PWL(0.0n 3.3V 200.0n 3.3V 230.0n 0.0V 400.0n 0.0V 430n 3.3V 600.0n 3.3V 630n 0V 800.0n 0V 830n 3.3V 1000.0n 3.3V 1030n 0V)

* PWL waveform for D
VD D 0 PWL(240n 3.3V 270n 0.0V 300n 0V 330n 3.3V 350n 3.3V 380n 0V 680n 0V 710n 0V 740n 3.3V 850n 3.3V 880n 0V 910n 3.3V)
