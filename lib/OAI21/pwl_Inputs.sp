* PWL waveform for A
VA A 0 PWL(0.0n 0.0V 30.0n 0.0V 200.0n 0.0V 230.0n 3.3V 400.0n 3.3V 430.0n 0.0V 600.0n 0.0V 630.0n 0.0V 800.0n 0.0V 830.0n 0.0V 1000.0n 0.0V 1030.0n 3.3V 1200.0n 3.3V 1230.0n 0.0V 1400.0n 0.0V 1430.0n 0.0V 1600.0n 0.0V 1630.0n 0.0V 1800.0n 0.0V 1830.0n 3.3V 2000.0n 3.3V 2030.0n 0.0V 2200.0n 0.0V 2230.0n 0.0V 2400.0n 0.0V 2430.0n 0.0V 2600.0n 0.0V 2630.0n 3.3V 2800.0n 3.3V 2830.0n 3.3V 3000.0n 3.3V 3030.0n 0.0V 3200.0n 0.0V 3230.0n 3.3V 3400.0n 3.3V 3430.0n 3.3V 3600.0n 3.3V 3630.0n 3.3V 3800.0n 3.3V 3830.0n 0.0V 4000.0n 0.0V 4030.0n 3.3V 4200.0n 3.3V 4230.0n 3.3V 4400.0n 3.3V 4430.0n 3.3V 4600.0n 3.3V 4630.0n 0.0V 4800.0n 0.0V 4830.0n 3.3V 5000.0n 3.3V 5030.0n 3.3V 5200.0n 3.3V 5230.0n 0.0V 5400.0n 0.0V 5430.0n 3.3V 5600.0n 3.3V 5630.0n 0.0V 5800.0n 0.0V 5830.0n 0.0V 6000.0n 0.0V 6030.0n 0.0V 6200.0n 0.0V 6230.0n 3.3V 6400.0n 3.3V 6430.0n 0.0V 6600.0n 0.0V 6630.0n 0.0V 6800.0n 0.0V 6830.0n 0.0V 7000.0n 0.0V 7030.0n 3.3V 7200.0n 3.3V 7230.0n 3.3V 7400.0n 3.3V 7430.0n 0.0V 7600.0n 0.0V 7630.0n 3.3V 7800.0n 3.3V 7830.0n 3.3V 8000.0n 3.3V 8030.0n 3.3V 8200.0n 3.3V 8230.0n 0.0V 8400.0n 0.0V 8430.0n 3.3V 8600.0n 3.3V 8630.0n 3.3V 8800.0n 3.3V 8830.0n 0.0V 9000.0n 0.0V 9030.0n 3.3V 9200.0n 3.3V 9230.0n 0.0V 9400.0n 0.0V 9430.0n 0.0V 9600.0n 0.0V 9630.0n 0.0V 9800.0n 0.0V 9830.0n 3.3V 10000.0n 3.3V 10030.0n 3.3V 10200.0n 3.3V 10230.0n 0.0V 10400.0n 0.0V 10430.0n 3.3V 10600.0n 3.3V 10630.0n 3.3V 10800.0n 3.3V 10830.0n 0.0V 11000.0n 0.0V 11030.0n 3.3V 11200.0n 3.3V 11230.0n 0.0V)
* PWL waveform for B1
VB1 B1 0 PWL(0.0n 0.0V 30.0n 0.0V 200.0n 0.0V 230.0n 0.0V 400.0n 0.0V 430.0n 0.0V 600.0n 0.0V 630.0n 3.3V 800.0n 3.3V 830.0n 0.0V 1000.0n 0.0V 1030.0n 3.3V 1200.0n 3.3V 1230.0n 0.0V 1400.0n 0.0V 1430.0n 0.0V 1600.0n 0.0V 1630.0n 0.0V 1800.0n 0.0V 1830.0n 0.0V 2000.0n 0.0V 2030.0n 0.0V 2200.0n 0.0V 2230.0n 3.3V 2400.0n 3.3V 2430.0n 0.0V 2600.0n 0.0V 2630.0n 3.3V 2800.0n 3.3V 2830.0n 0.0V 3000.0n 0.0V 3030.0n 3.3V 3200.0n 3.3V 3230.0n 0.0V 3400.0n 0.0V 3430.0n 3.3V 3600.0n 3.3V 3630.0n 0.0V 3800.0n 0.0V 3830.0n 0.0V 4000.0n 0.0V 4030.0n 0.0V 4200.0n 0.0V 4230.0n 0.0V 4400.0n 0.0V 4430.0n 0.0V 4600.0n 0.0V 4630.0n 3.3V 4800.0n 3.3V 4830.0n 0.0V 5000.0n 0.0V 5030.0n 3.3V 5200.0n 3.3V 5230.0n 3.3V 5400.0n 3.3V 5430.0n 3.3V 5600.0n 3.3V 5630.0n 3.3V 5800.0n 3.3V 5830.0n 0.0V 6000.0n 0.0V 6030.0n 3.3V 6200.0n 3.3V 6230.0n 0.0V 6400.0n 0.0V 6430.0n 3.3V 6600.0n 3.3V 6630.0n 3.3V 6800.0n 3.3V 6830.0n 3.3V 7000.0n 3.3V 7030.0n 3.3V 7200.0n 3.3V 7230.0n 3.3V 7400.0n 3.3V 7430.0n 0.0V 7600.0n 0.0V 7630.0n 3.3V 7800.0n 3.3V 7830.0n 0.0V 8000.0n 0.0V 8030.0n 3.3V 8200.0n 3.3V 8230.0n 3.3V 8400.0n 3.3V 8430.0n 3.3V 8600.0n 3.3V 8630.0n 3.3V 8800.0n 3.3V 8830.0n 0.0V 9000.0n 0.0V 9030.0n 0.0V 9200.0n 0.0V 9230.0n 0.0V 9400.0n 0.0V 9430.0n 3.3V 9600.0n 3.3V 9630.0n 0.0V 9800.0n 0.0V 9830.0n 3.3V 10000.0n 3.3V 10030.0n 0.0V 10200.0n 0.0V 10230.0n 3.3V 10400.0n 3.3V 10430.0n 0.0V 10600.0n 0.0V 10630.0n 3.3V 10800.0n 3.3V 10830.0n 3.3V 11000.0n 3.3V 11030.0n 3.3V 11200.0n 3.3V 11230.0n 0.0V)
* PWL waveform for B2
VB2 B2 0 PWL(0.0n 0.0V 30.0n 0.0V 200.0n 0.0V 230.0n 0.0V 400.0n 0.0V 430.0n 0.0V 600.0n 0.0V 630.0n 0.0V 800.0n 0.0V 830.0n 0.0V 1000.0n 0.0V 1030.0n 0.0V 1200.0n 0.0V 1230.0n 0.0V 1400.0n 0.0V 1430.0n 3.3V 1600.0n 3.3V 1630.0n 0.0V 1800.0n 0.0V 1830.0n 3.3V 2000.0n 3.3V 2030.0n 0.0V 2200.0n 0.0V 2230.0n 3.3V 2400.0n 3.3V 2430.0n 0.0V 2600.0n 0.0V 2630.0n 3.3V 2800.0n 3.3V 2830.0n 0.0V 3000.0n 0.0V 3030.0n 0.0V 3200.0n 0.0V 3230.0n 0.0V 3400.0n 0.0V 3430.0n 0.0V 3600.0n 0.0V 3630.0n 0.0V 3800.0n 0.0V 3830.0n 3.3V 4000.0n 3.3V 4030.0n 0.0V 4200.0n 0.0V 4230.0n 3.3V 4400.0n 3.3V 4430.0n 0.0V 4600.0n 0.0V 4630.0n 3.3V 4800.0n 3.3V 4830.0n 0.0V 5000.0n 0.0V 5030.0n 3.3V 5200.0n 3.3V 5230.0n 0.0V 5400.0n 0.0V 5430.0n 0.0V 5600.0n 0.0V 5630.0n 0.0V 5800.0n 0.0V 5830.0n 3.3V 6000.0n 3.3V 6030.0n 0.0V 6200.0n 0.0V 6230.0n 3.3V 6400.0n 3.3V 6430.0n 0.0V 6600.0n 0.0V 6630.0n 3.3V 6800.0n 3.3V 6830.0n 0.0V 7000.0n 0.0V 7030.0n 3.3V 7200.0n 3.3V 7230.0n 0.0V 7400.0n 0.0V 7430.0n 3.3V 7600.0n 3.3V 7630.0n 0.0V 7800.0n 0.0V 7830.0n 3.3V 8000.0n 3.3V 8030.0n 0.0V 8200.0n 0.0V 8230.0n 3.3V 8400.0n 3.3V 8430.0n 0.0V 8600.0n 0.0V 8630.0n 3.3V 8800.0n 3.3V 8830.0n 3.3V 9000.0n 3.3V 9030.0n 3.3V 9200.0n 3.3V 9230.0n 3.3V 9400.0n 3.3V 9430.0n 3.3V 9600.0n 3.3V 9630.0n 3.3V 9800.0n 3.3V 9830.0n 3.3V 10000.0n 3.3V 10030.0n 3.3V 10200.0n 3.3V 10230.0n 3.3V 10400.0n 3.3V 10430.0n 3.3V 10600.0n 3.3V 10630.0n 3.3V 10800.0n 3.3V 10830.0n 3.3V 11000.0n 3.3V 11030.0n 3.3V 11200.0n 3.3V 11230.0n 0.0V)
