* PWL waveform for A1
VA1 A1 0 PWL(0.0n 0V 30.0n 0V 200.0n 0V 230.0n {vdd} 400.0n {vdd} 430.0n 0V 600.0n 0V 630.0n 0V 800.0n 0V 830.0n 0V 1000.0n 0V 1030.0n {vdd} 1200.0n {vdd} 1230.0n 0V 1400.0n 0V 1430.0n 0V 1600.0n 0V 1630.0n 0V 1800.0n 0V 1830.0n {vdd} 2000.0n {vdd} 2030.0n 0V 2200.0n 0V 2230.0n 0V 2400.0n 0V 2430.0n 0V 2600.0n 0V 2630.0n {vdd} 2800.0n {vdd} 2830.0n 0V 3000.0n 0V 3030.0n 0V 3200.0n 0V 3230.0n 0V 3400.0n 0V 3430.0n {vdd} 3600.0n {vdd} 3630.0n 0V 3800.0n 0V 3830.0n 0V 4000.0n 0V 4030.0n 0V 4200.0n 0V 4230.0n {vdd} 4400.0n {vdd} 4430.0n 0V 4600.0n 0V 4630.0n 0V 4800.0n 0V 4830.0n 0V 5000.0n 0V 5030.0n {vdd} 5200.0n {vdd} 5230.0n 0V 5400.0n 0V 5430.0n 0V 5600.0n 0V 5630.0n 0V 5800.0n 0V 5830.0n {vdd} 6000.0n {vdd} 6030.0n {vdd} 6200.0n {vdd} 6230.0n 0V 6400.0n 0V 6430.0n {vdd} 6600.0n {vdd} 6630.0n {vdd} 6800.0n {vdd} 6830.0n {vdd} 7000.0n {vdd} 7030.0n 0V 7200.0n 0V 7230.0n {vdd} 7400.0n {vdd} 7430.0n {vdd} 7600.0n {vdd} 7630.0n {vdd} 7800.0n {vdd} 7830.0n 0V 8000.0n 0V 8030.0n {vdd} 8200.0n {vdd} 8230.0n {vdd} 8400.0n {vdd} 8430.0n {vdd} 8600.0n {vdd} 8630.0n 0V 8800.0n 0V 8830.0n {vdd} 9000.0n {vdd} 9030.0n {vdd} 9200.0n {vdd} 9230.0n {vdd} 9400.0n {vdd} 9430.0n 0V 9600.0n 0V 9630.0n {vdd} 9800.0n {vdd} 9830.0n {vdd} 10000.0n {vdd} 10030.0n {vdd} 10200.0n {vdd} 10230.0n 0V 10400.0n 0V 10430.0n {vdd} 10600.0n {vdd} 10630.0n {vdd} 10800.0n {vdd} 10830.0n {vdd} 11000.0n {vdd} 11030.0n 0V 11200.0n 0V 11230.0n {vdd} 11400.0n {vdd} 11430.0n {vdd} 11600.0n {vdd} 11630.0n 0V 11800.0n 0V 11830.0n {vdd} 12000.0n {vdd} 12030.0n 0V 12200.0n 0V 12230.0n 0V 12400.0n 0V 12430.0n 0V 12600.0n 0V 12630.0n {vdd} 12800.0n {vdd} 12830.0n 0V 13000.0n 0V 13030.0n 0V 13200.0n 0V 13230.0n 0V 13400.0n 0V 13430.0n {vdd} 13600.0n {vdd} 13630.0n 0V 13800.0n 0V 13830.0n 0V 14000.0n 0V 14030.0n 0V 14200.0n 0V 14230.0n {vdd} 14400.0n {vdd} 14430.0n 0V 14600.0n 0V 14630.0n 0V 14800.0n 0V 14830.0n 0V 15000.0n 0V 15030.0n {vdd} 15200.0n {vdd} 15230.0n 0V 15400.0n 0V 15430.0n 0V 15600.0n 0V 15630.0n 0V 15800.0n 0V 15830.0n {vdd} 16000.0n {vdd} 16030.0n 0V 16200.0n 0V 16230.0n 0V 16400.0n 0V 16430.0n 0V 16600.0n 0V 16630.0n {vdd} 16800.0n {vdd} 16830.0n {vdd} 17000.0n {vdd} 17030.0n 0V 17200.0n 0V 17230.0n {vdd} 17400.0n {vdd} 17430.0n {vdd} 17600.0n {vdd} 17630.0n {vdd} 17800.0n {vdd} 17830.0n 0V 18000.0n 0V 18030.0n {vdd} 18200.0n {vdd} 18230.0n {vdd} 18400.0n {vdd} 18430.0n {vdd} 18600.0n {vdd} 18630.0n 0V 18800.0n 0V 18830.0n {vdd} 19000.0n {vdd} 19030.0n {vdd} 19200.0n {vdd} 19230.0n {vdd} 19400.0n {vdd} 19430.0n 0V 19600.0n 0V 19630.0n {vdd} 19800.0n {vdd} 19830.0n {vdd} 20000.0n {vdd} 20030.0n {vdd} 20200.0n {vdd} 20230.0n 0V 20400.0n 0V 20430.0n {vdd} 20600.0n {vdd} 20630.0n {vdd} 20800.0n {vdd} 20830.0n {vdd} 21000.0n {vdd} 21030.0n 0V 21200.0n 0V 21230.0n {vdd} 21400.0n {vdd} 21430.0n {vdd} 21600.0n {vdd} 21630.0n 0V 21800.0n 0V 21830.0n {vdd} 22000.0n {vdd} 22030.0n 0V 22200.0n 0V 22230.0n 0V 22400.0n 0V 22430.0n 0V 22600.0n 0V 22630.0n {vdd} 22800.0n {vdd} 22830.0n 0V 23000.0n 0V 23030.0n 0V 23200.0n 0V 23230.0n 0V 23400.0n 0V 23430.0n {vdd} 23600.0n {vdd} 23630.0n 0V 23800.0n 0V 23830.0n 0V 24000.0n 0V 24030.0n 0V 24200.0n 0V 24230.0n {vdd} 24400.0n {vdd} 24430.0n 0V 24600.0n 0V 24630.0n 0V 24800.0n 0V 24830.0n 0V 25000.0n 0V 25030.0n {vdd} 25200.0n {vdd} 25230.0n 0V 25400.0n 0V 25430.0n 0V 25600.0n 0V 25630.0n 0V 25800.0n 0V 25830.0n {vdd} 26000.0n {vdd} 26030.0n {vdd} 26200.0n {vdd} 26230.0n 0V 26400.0n 0V 26430.0n {vdd} 26600.0n {vdd} 26630.0n {vdd} 26800.0n {vdd} 26830.0n {vdd} 27000.0n {vdd} 27030.0n 0V 27200.0n 0V 27230.0n {vdd} 27400.0n {vdd} 27430.0n {vdd} 27600.0n {vdd} 27630.0n {vdd} 27800.0n {vdd} 27830.0n 0V 28000.0n 0V 28030.0n {vdd} 28200.0n {vdd} 28230.0n {vdd} 28400.0n {vdd} 28430.0n {vdd} 28600.0n {vdd} 28630.0n 0V 28800.0n 0V 28830.0n {vdd} 29000.0n {vdd} 29030.0n {vdd} 29200.0n {vdd} 29230.0n {vdd} 29400.0n {vdd} 29430.0n 0V 29600.0n 0V 29630.0n {vdd} 29800.0n {vdd} 29830.0n {vdd} 30000.0n {vdd} 30030.0n 0V 30200.0n 0V 30230.0n {vdd} 30400.0n {vdd} 30430.0n 0V 30600.0n 0V 30630.0n 0V 30800.0n 0V 30830.0n 0V 31000.0n 0V 31030.0n {vdd} 31200.0n {vdd} 31230.0n 0V 31400.0n 0V 31430.0n 0V 31600.0n 0V 31630.0n 0V 31800.0n 0V 31830.0n {vdd} 32000.0n {vdd} 32030.0n 0V 32200.0n 0V 32230.0n 0V 32400.0n 0V 32430.0n 0V 32600.0n 0V 32630.0n {vdd} 32800.0n {vdd} 32830.0n 0V 33000.0n 0V 33030.0n 0V 33200.0n 0V 33230.0n 0V 33400.0n 0V 33430.0n {vdd} 33600.0n {vdd} 33630.0n {vdd} 33800.0n {vdd} 33830.0n 0V 34000.0n 0V 34030.0n {vdd} 34200.0n {vdd} 34230.0n {vdd} 34400.0n {vdd} 34430.0n {vdd} 34600.0n {vdd} 34630.0n 0V 34800.0n 0V 34830.0n {vdd} 35000.0n {vdd} 35030.0n {vdd} 35200.0n {vdd} 35230.0n {vdd} 35400.0n {vdd} 35430.0n 0V 35600.0n 0V 35630.0n {vdd} 35800.0n {vdd} 35830.0n {vdd} 36000.0n {vdd} 36030.0n {vdd} 36200.0n {vdd} 36230.0n 0V 36400.0n 0V 36430.0n {vdd} 36600.0n {vdd} 36630.0n {vdd} 36800.0n {vdd} 36830.0n 0V 37000.0n 0V 37030.0n {vdd} 37200.0n {vdd} 37230.0n 0V 37400.0n 0V 37430.0n 0V 37600.0n 0V 37630.0n 0V 37800.0n 0V 37830.0n {vdd} 38000.0n {vdd} 38030.0n 0V 38200.0n 0V 38230.0n 0V 38400.0n 0V 38430.0n 0V 38600.0n 0V 38630.0n {vdd} 38800.0n {vdd} 38830.0n 0V 39000.0n 0V 39030.0n 0V 39200.0n 0V 39230.0n 0V 39400.0n 0V 39430.0n {vdd} 39600.0n {vdd} 39630.0n {vdd} 39800.0n {vdd} 39830.0n 0V 40000.0n 0V 40030.0n {vdd} 40200.0n {vdd} 40230.0n {vdd} 40400.0n {vdd} 40430.0n {vdd} 40600.0n {vdd} 40630.0n 0V 40800.0n 0V 40830.0n {vdd} 41000.0n {vdd} 41030.0n {vdd} 41200.0n {vdd} 41230.0n {vdd} 41400.0n {vdd} 41430.0n 0V 41600.0n 0V 41630.0n {vdd} 41800.0n {vdd} 41830.0n {vdd} 42000.0n {vdd} 42030.0n 0V 42200.0n 0V 42230.0n {vdd} 42400.0n {vdd} 42430.0n 0V 42600.0n 0V 42630.0n 0V 42800.0n 0V 42830.0n 0V 43000.0n 0V 43030.0n {vdd} 43200.0n {vdd} 43230.0n 0V 43400.0n 0V 43430.0n 0V 43600.0n 0V 43630.0n 0V 43800.0n 0V 43830.0n {vdd} 44000.0n {vdd} 44030.0n {vdd} 44200.0n {vdd} 44230.0n 0V 44400.0n 0V 44430.0n {vdd} 44600.0n {vdd} 44630.0n {vdd} 44800.0n {vdd} 44830.0n {vdd} 45000.0n {vdd} 45030.0n 0V 45200.0n 0V 45230.0n {vdd} 45400.0n {vdd} 45430.0n {vdd} 45600.0n {vdd} 45630.0n 0V 45800.0n 0V 45830.0n {vdd} 46000.0n {vdd} 46030.0n 0V 46200.0n 0V 46230.0n 0V 46400.0n 0V 46430.0n 0V 46600.0n 0V 46630.0n {vdd} 46800.0n {vdd} 46830.0n {vdd} 47000.0n {vdd} 47030.0n 0V 47200.0n 0V 47230.0n {vdd} 47400.0n {vdd} 47430.0n {vdd} 47600.0n {vdd} 47630.0n 0V 47800.0n 0V 47830.0n {vdd} 48000.0n {vdd} 48030.0n 0V)
* PWL waveform for A2
VA2 A2 0 PWL(0.0n 0V 30.0n 0V 200.0n 0V 230.0n 0V 400.0n 0V 430.0n 0V 600.0n 0V 630.0n {vdd} 800.0n {vdd} 830.0n 0V 1000.0n 0V 1030.0n {vdd} 1200.0n {vdd} 1230.0n 0V 1400.0n 0V 1430.0n 0V 1600.0n 0V 1630.0n 0V 1800.0n 0V 1830.0n 0V 2000.0n 0V 2030.0n 0V 2200.0n 0V 2230.0n {vdd} 2400.0n {vdd} 2430.0n 0V 2600.0n 0V 2630.0n {vdd} 2800.0n {vdd} 2830.0n 0V 3000.0n 0V 3030.0n 0V 3200.0n 0V 3230.0n 0V 3400.0n 0V 3430.0n 0V 3600.0n 0V 3630.0n 0V 3800.0n 0V 3830.0n {vdd} 4000.0n {vdd} 4030.0n 0V 4200.0n 0V 4230.0n {vdd} 4400.0n {vdd} 4430.0n 0V 4600.0n 0V 4630.0n 0V 4800.0n 0V 4830.0n 0V 5000.0n 0V 5030.0n 0V 5200.0n 0V 5230.0n 0V 5400.0n 0V 5430.0n {vdd} 5600.0n {vdd} 5630.0n 0V 5800.0n 0V 5830.0n {vdd} 6000.0n {vdd} 6030.0n 0V 6200.0n 0V 6230.0n {vdd} 6400.0n {vdd} 6430.0n 0V 6600.0n 0V 6630.0n {vdd} 6800.0n {vdd} 6830.0n 0V 7000.0n 0V 7030.0n 0V 7200.0n 0V 7230.0n 0V 7400.0n 0V 7430.0n 0V 7600.0n 0V 7630.0n 0V 7800.0n 0V 7830.0n {vdd} 8000.0n {vdd} 8030.0n 0V 8200.0n 0V 8230.0n {vdd} 8400.0n {vdd} 8430.0n 0V 8600.0n 0V 8630.0n 0V 8800.0n 0V 8830.0n 0V 9000.0n 0V 9030.0n 0V 9200.0n 0V 9230.0n 0V 9400.0n 0V 9430.0n {vdd} 9600.0n {vdd} 9630.0n 0V 9800.0n 0V 9830.0n {vdd} 10000.0n {vdd} 10030.0n 0V 10200.0n 0V 10230.0n 0V 10400.0n 0V 10430.0n 0V 10600.0n 0V 10630.0n 0V 10800.0n 0V 10830.0n 0V 11000.0n 0V 11030.0n {vdd} 11200.0n {vdd} 11230.0n 0V 11400.0n 0V 11430.0n {vdd} 11600.0n {vdd} 11630.0n {vdd} 11800.0n {vdd} 11830.0n {vdd} 12000.0n {vdd} 12030.0n {vdd} 12200.0n {vdd} 12230.0n 0V 12400.0n 0V 12430.0n {vdd} 12600.0n {vdd} 12630.0n 0V 12800.0n 0V 12830.0n {vdd} 13000.0n {vdd} 13030.0n {vdd} 13200.0n {vdd} 13230.0n {vdd} 13400.0n {vdd} 13430.0n {vdd} 13600.0n {vdd} 13630.0n {vdd} 13800.0n {vdd} 13830.0n 0V 14000.0n 0V 14030.0n {vdd} 14200.0n {vdd} 14230.0n 0V 14400.0n 0V 14430.0n {vdd} 14600.0n {vdd} 14630.0n {vdd} 14800.0n {vdd} 14830.0n {vdd} 15000.0n {vdd} 15030.0n {vdd} 15200.0n {vdd} 15230.0n {vdd} 15400.0n {vdd} 15430.0n 0V 15600.0n 0V 15630.0n {vdd} 15800.0n {vdd} 15830.0n 0V 16000.0n 0V 16030.0n {vdd} 16200.0n {vdd} 16230.0n {vdd} 16400.0n {vdd} 16430.0n {vdd} 16600.0n {vdd} 16630.0n {vdd} 16800.0n {vdd} 16830.0n {vdd} 17000.0n {vdd} 17030.0n 0V 17200.0n 0V 17230.0n {vdd} 17400.0n {vdd} 17430.0n 0V 17600.0n 0V 17630.0n {vdd} 17800.0n {vdd} 17830.0n {vdd} 18000.0n {vdd} 18030.0n {vdd} 18200.0n {vdd} 18230.0n {vdd} 18400.0n {vdd} 18430.0n {vdd} 18600.0n {vdd} 18630.0n 0V 18800.0n 0V 18830.0n {vdd} 19000.0n {vdd} 19030.0n 0V 19200.0n 0V 19230.0n {vdd} 19400.0n {vdd} 19430.0n {vdd} 19600.0n {vdd} 19630.0n {vdd} 19800.0n {vdd} 19830.0n {vdd} 20000.0n {vdd} 20030.0n {vdd} 20200.0n {vdd} 20230.0n 0V 20400.0n 0V 20430.0n {vdd} 20600.0n {vdd} 20630.0n 0V 20800.0n 0V 20830.0n {vdd} 21000.0n {vdd} 21030.0n {vdd} 21200.0n {vdd} 21230.0n {vdd} 21400.0n {vdd} 21430.0n {vdd} 21600.0n {vdd} 21630.0n 0V 21800.0n 0V 21830.0n 0V 22000.0n 0V 22030.0n 0V 22200.0n 0V 22230.0n {vdd} 22400.0n {vdd} 22430.0n 0V 22600.0n 0V 22630.0n {vdd} 22800.0n {vdd} 22830.0n 0V 23000.0n 0V 23030.0n 0V 23200.0n 0V 23230.0n 0V 23400.0n 0V 23430.0n 0V 23600.0n 0V 23630.0n 0V 23800.0n 0V 23830.0n {vdd} 24000.0n {vdd} 24030.0n 0V 24200.0n 0V 24230.0n {vdd} 24400.0n {vdd} 24430.0n 0V 24600.0n 0V 24630.0n 0V 24800.0n 0V 24830.0n 0V 25000.0n 0V 25030.0n 0V 25200.0n 0V 25230.0n 0V 25400.0n 0V 25430.0n {vdd} 25600.0n {vdd} 25630.0n 0V 25800.0n 0V 25830.0n {vdd} 26000.0n {vdd} 26030.0n 0V 26200.0n 0V 26230.0n {vdd} 26400.0n {vdd} 26430.0n 0V 26600.0n 0V 26630.0n {vdd} 26800.0n {vdd} 26830.0n 0V 27000.0n 0V 27030.0n 0V 27200.0n 0V 27230.0n 0V 27400.0n 0V 27430.0n 0V 27600.0n 0V 27630.0n 0V 27800.0n 0V 27830.0n {vdd} 28000.0n {vdd} 28030.0n 0V 28200.0n 0V 28230.0n {vdd} 28400.0n {vdd} 28430.0n 0V 28600.0n 0V 28630.0n 0V 28800.0n 0V 28830.0n 0V 29000.0n 0V 29030.0n 0V 29200.0n 0V 29230.0n 0V 29400.0n 0V 29430.0n {vdd} 29600.0n {vdd} 29630.0n 0V 29800.0n 0V 29830.0n {vdd} 30000.0n {vdd} 30030.0n {vdd} 30200.0n {vdd} 30230.0n {vdd} 30400.0n {vdd} 30430.0n {vdd} 30600.0n {vdd} 30630.0n 0V 30800.0n 0V 30830.0n {vdd} 31000.0n {vdd} 31030.0n 0V 31200.0n 0V 31230.0n {vdd} 31400.0n {vdd} 31430.0n {vdd} 31600.0n {vdd} 31630.0n {vdd} 31800.0n {vdd} 31830.0n {vdd} 32000.0n {vdd} 32030.0n {vdd} 32200.0n {vdd} 32230.0n 0V 32400.0n 0V 32430.0n {vdd} 32600.0n {vdd} 32630.0n 0V 32800.0n 0V 32830.0n {vdd} 33000.0n {vdd} 33030.0n {vdd} 33200.0n {vdd} 33230.0n {vdd} 33400.0n {vdd} 33430.0n {vdd} 33600.0n {vdd} 33630.0n {vdd} 33800.0n {vdd} 33830.0n 0V 34000.0n 0V 34030.0n {vdd} 34200.0n {vdd} 34230.0n 0V 34400.0n 0V 34430.0n {vdd} 34600.0n {vdd} 34630.0n {vdd} 34800.0n {vdd} 34830.0n {vdd} 35000.0n {vdd} 35030.0n {vdd} 35200.0n {vdd} 35230.0n {vdd} 35400.0n {vdd} 35430.0n 0V 35600.0n 0V 35630.0n {vdd} 35800.0n {vdd} 35830.0n 0V 36000.0n 0V 36030.0n {vdd} 36200.0n {vdd} 36230.0n {vdd} 36400.0n {vdd} 36430.0n {vdd} 36600.0n {vdd} 36630.0n {vdd} 36800.0n {vdd} 36830.0n 0V 37000.0n 0V 37030.0n 0V 37200.0n 0V 37230.0n 0V 37400.0n 0V 37430.0n {vdd} 37600.0n {vdd} 37630.0n 0V 37800.0n 0V 37830.0n {vdd} 38000.0n {vdd} 38030.0n 0V 38200.0n 0V 38230.0n 0V 38400.0n 0V 38430.0n 0V 38600.0n 0V 38630.0n 0V 38800.0n 0V 38830.0n 0V 39000.0n 0V 39030.0n {vdd} 39200.0n {vdd} 39230.0n 0V 39400.0n 0V 39430.0n {vdd} 39600.0n {vdd} 39630.0n 0V 39800.0n 0V 39830.0n {vdd} 40000.0n {vdd} 40030.0n 0V 40200.0n 0V 40230.0n {vdd} 40400.0n {vdd} 40430.0n 0V 40600.0n 0V 40630.0n 0V 40800.0n 0V 40830.0n 0V 41000.0n 0V 41030.0n 0V 41200.0n 0V 41230.0n 0V 41400.0n 0V 41430.0n {vdd} 41600.0n {vdd} 41630.0n 0V 41800.0n 0V 41830.0n {vdd} 42000.0n {vdd} 42030.0n {vdd} 42200.0n {vdd} 42230.0n {vdd} 42400.0n {vdd} 42430.0n {vdd} 42600.0n {vdd} 42630.0n 0V 42800.0n 0V 42830.0n {vdd} 43000.0n {vdd} 43030.0n 0V 43200.0n 0V 43230.0n {vdd} 43400.0n {vdd} 43430.0n {vdd} 43600.0n {vdd} 43630.0n {vdd} 43800.0n {vdd} 43830.0n {vdd} 44000.0n {vdd} 44030.0n {vdd} 44200.0n {vdd} 44230.0n 0V 44400.0n 0V 44430.0n {vdd} 44600.0n {vdd} 44630.0n 0V 44800.0n 0V 44830.0n {vdd} 45000.0n {vdd} 45030.0n {vdd} 45200.0n {vdd} 45230.0n {vdd} 45400.0n {vdd} 45430.0n {vdd} 45600.0n {vdd} 45630.0n 0V 45800.0n 0V 45830.0n 0V 46000.0n 0V 46030.0n 0V 46200.0n 0V 46230.0n {vdd} 46400.0n {vdd} 46430.0n 0V 46600.0n 0V 46630.0n {vdd} 46800.0n {vdd} 46830.0n 0V 47000.0n 0V 47030.0n {vdd} 47200.0n {vdd} 47230.0n 0V 47400.0n 0V 47430.0n {vdd} 47600.0n {vdd} 47630.0n {vdd} 47800.0n {vdd} 47830.0n {vdd} 48000.0n {vdd} 48030.0n 0V)
* PWL waveform for A3
VA3 A3 0 PWL(0.0n 0V 30.0n 0V 200.0n 0V 230.0n 0V 400.0n 0V 430.0n 0V 600.0n 0V 630.0n 0V 800.0n 0V 830.0n 0V 1000.0n 0V 1030.0n 0V 1200.0n 0V 1230.0n 0V 1400.0n 0V 1430.0n {vdd} 1600.0n {vdd} 1630.0n 0V 1800.0n 0V 1830.0n {vdd} 2000.0n {vdd} 2030.0n 0V 2200.0n 0V 2230.0n {vdd} 2400.0n {vdd} 2430.0n 0V 2600.0n 0V 2630.0n {vdd} 2800.0n {vdd} 2830.0n 0V 3000.0n 0V 3030.0n 0V 3200.0n 0V 3230.0n 0V 3400.0n 0V 3430.0n 0V 3600.0n 0V 3630.0n 0V 3800.0n 0V 3830.0n 0V 4000.0n 0V 4030.0n 0V 4200.0n 0V 4230.0n 0V 4400.0n 0V 4430.0n 0V 4600.0n 0V 4630.0n {vdd} 4800.0n {vdd} 4830.0n 0V 5000.0n 0V 5030.0n {vdd} 5200.0n {vdd} 5230.0n 0V 5400.0n 0V 5430.0n {vdd} 5600.0n {vdd} 5630.0n 0V 5800.0n 0V 5830.0n {vdd} 6000.0n {vdd} 6030.0n 0V 6200.0n 0V 6230.0n 0V 6400.0n 0V 6430.0n 0V 6600.0n 0V 6630.0n 0V 6800.0n 0V 6830.0n 0V 7000.0n 0V 7030.0n {vdd} 7200.0n {vdd} 7230.0n 0V 7400.0n 0V 7430.0n {vdd} 7600.0n {vdd} 7630.0n 0V 7800.0n 0V 7830.0n {vdd} 8000.0n {vdd} 8030.0n 0V 8200.0n 0V 8230.0n {vdd} 8400.0n {vdd} 8430.0n 0V 8600.0n 0V 8630.0n 0V 8800.0n 0V 8830.0n 0V 9000.0n 0V 9030.0n 0V 9200.0n 0V 9230.0n 0V 9400.0n 0V 9430.0n 0V 9600.0n 0V 9630.0n 0V 9800.0n 0V 9830.0n 0V 10000.0n 0V 10030.0n 0V 10200.0n 0V 10230.0n {vdd} 10400.0n {vdd} 10430.0n 0V 10600.0n 0V 10630.0n {vdd} 10800.0n {vdd} 10830.0n 0V 11000.0n 0V 11030.0n {vdd} 11200.0n {vdd} 11230.0n 0V 11400.0n 0V 11430.0n {vdd} 11600.0n {vdd} 11630.0n 0V 11800.0n 0V 11830.0n 0V 12000.0n 0V 12030.0n 0V 12200.0n 0V 12230.0n {vdd} 12400.0n {vdd} 12430.0n 0V 12600.0n 0V 12630.0n {vdd} 12800.0n {vdd} 12830.0n 0V 13000.0n 0V 13030.0n {vdd} 13200.0n {vdd} 13230.0n 0V 13400.0n 0V 13430.0n {vdd} 13600.0n {vdd} 13630.0n 0V 13800.0n 0V 13830.0n 0V 14000.0n 0V 14030.0n 0V 14200.0n 0V 14230.0n 0V 14400.0n 0V 14430.0n 0V 14600.0n 0V 14630.0n 0V 14800.0n 0V 14830.0n 0V 15000.0n 0V 15030.0n 0V 15200.0n 0V 15230.0n 0V 15400.0n 0V 15430.0n {vdd} 15600.0n {vdd} 15630.0n 0V 15800.0n 0V 15830.0n {vdd} 16000.0n {vdd} 16030.0n 0V 16200.0n 0V 16230.0n {vdd} 16400.0n {vdd} 16430.0n 0V 16600.0n 0V 16630.0n {vdd} 16800.0n {vdd} 16830.0n 0V 17000.0n 0V 17030.0n {vdd} 17200.0n {vdd} 17230.0n 0V 17400.0n 0V 17430.0n {vdd} 17600.0n {vdd} 17630.0n 0V 17800.0n 0V 17830.0n {vdd} 18000.0n {vdd} 18030.0n 0V 18200.0n 0V 18230.0n {vdd} 18400.0n {vdd} 18430.0n 0V 18600.0n 0V 18630.0n 0V 18800.0n 0V 18830.0n 0V 19000.0n 0V 19030.0n 0V 19200.0n 0V 19230.0n 0V 19400.0n 0V 19430.0n 0V 19600.0n 0V 19630.0n 0V 19800.0n 0V 19830.0n 0V 20000.0n 0V 20030.0n 0V 20200.0n 0V 20230.0n {vdd} 20400.0n {vdd} 20430.0n 0V 20600.0n 0V 20630.0n {vdd} 20800.0n {vdd} 20830.0n 0V 21000.0n 0V 21030.0n {vdd} 21200.0n {vdd} 21230.0n 0V 21400.0n 0V 21430.0n {vdd} 21600.0n {vdd} 21630.0n {vdd} 21800.0n {vdd} 21830.0n {vdd} 22000.0n {vdd} 22030.0n {vdd} 22200.0n {vdd} 22230.0n {vdd} 22400.0n {vdd} 22430.0n {vdd} 22600.0n {vdd} 22630.0n {vdd} 22800.0n {vdd} 22830.0n {vdd} 23000.0n {vdd} 23030.0n 0V 23200.0n 0V 23230.0n {vdd} 23400.0n {vdd} 23430.0n 0V 23600.0n 0V 23630.0n {vdd} 23800.0n {vdd} 23830.0n 0V 24000.0n 0V 24030.0n {vdd} 24200.0n {vdd} 24230.0n 0V 24400.0n 0V 24430.0n {vdd} 24600.0n {vdd} 24630.0n {vdd} 24800.0n {vdd} 24830.0n {vdd} 25000.0n {vdd} 25030.0n {vdd} 25200.0n {vdd} 25230.0n {vdd} 25400.0n {vdd} 25430.0n {vdd} 25600.0n {vdd} 25630.0n {vdd} 25800.0n {vdd} 25830.0n {vdd} 26000.0n {vdd} 26030.0n {vdd} 26200.0n {vdd} 26230.0n {vdd} 26400.0n {vdd} 26430.0n {vdd} 26600.0n {vdd} 26630.0n {vdd} 26800.0n {vdd} 26830.0n {vdd} 27000.0n {vdd} 27030.0n 0V 27200.0n 0V 27230.0n {vdd} 27400.0n {vdd} 27430.0n 0V 27600.0n 0V 27630.0n {vdd} 27800.0n {vdd} 27830.0n 0V 28000.0n 0V 28030.0n {vdd} 28200.0n {vdd} 28230.0n 0V 28400.0n 0V 28430.0n {vdd} 28600.0n {vdd} 28630.0n {vdd} 28800.0n {vdd} 28830.0n {vdd} 29000.0n {vdd} 29030.0n {vdd} 29200.0n {vdd} 29230.0n {vdd} 29400.0n {vdd} 29430.0n {vdd} 29600.0n {vdd} 29630.0n {vdd} 29800.0n {vdd} 29830.0n {vdd} 30000.0n {vdd} 30030.0n {vdd} 30200.0n {vdd} 30230.0n {vdd} 30400.0n {vdd} 30430.0n {vdd} 30600.0n {vdd} 30630.0n 0V 30800.0n 0V 30830.0n {vdd} 31000.0n {vdd} 31030.0n 0V 31200.0n 0V 31230.0n {vdd} 31400.0n {vdd} 31430.0n 0V 31600.0n 0V 31630.0n {vdd} 31800.0n {vdd} 31830.0n 0V 32000.0n 0V 32030.0n {vdd} 32200.0n {vdd} 32230.0n {vdd} 32400.0n {vdd} 32430.0n {vdd} 32600.0n {vdd} 32630.0n {vdd} 32800.0n {vdd} 32830.0n {vdd} 33000.0n {vdd} 33030.0n {vdd} 33200.0n {vdd} 33230.0n {vdd} 33400.0n {vdd} 33430.0n {vdd} 33600.0n {vdd} 33630.0n {vdd} 33800.0n {vdd} 33830.0n 0V 34000.0n 0V 34030.0n {vdd} 34200.0n {vdd} 34230.0n 0V 34400.0n 0V 34430.0n {vdd} 34600.0n {vdd} 34630.0n 0V 34800.0n 0V 34830.0n {vdd} 35000.0n {vdd} 35030.0n 0V 35200.0n 0V 35230.0n {vdd} 35400.0n {vdd} 35430.0n {vdd} 35600.0n {vdd} 35630.0n {vdd} 35800.0n {vdd} 35830.0n {vdd} 36000.0n {vdd} 36030.0n {vdd} 36200.0n {vdd} 36230.0n {vdd} 36400.0n {vdd} 36430.0n {vdd} 36600.0n {vdd} 36630.0n {vdd} 36800.0n {vdd} 36830.0n 0V 37000.0n 0V 37030.0n 0V 37200.0n 0V 37230.0n 0V 37400.0n 0V 37430.0n 0V 37600.0n 0V 37630.0n 0V 37800.0n 0V 37830.0n 0V 38000.0n 0V 38030.0n 0V 38200.0n 0V 38230.0n {vdd} 38400.0n {vdd} 38430.0n 0V 38600.0n 0V 38630.0n {vdd} 38800.0n {vdd} 38830.0n 0V 39000.0n 0V 39030.0n {vdd} 39200.0n {vdd} 39230.0n 0V 39400.0n 0V 39430.0n {vdd} 39600.0n {vdd} 39630.0n 0V 39800.0n 0V 39830.0n 0V 40000.0n 0V 40030.0n 0V 40200.0n 0V 40230.0n 0V 40400.0n 0V 40430.0n 0V 40600.0n 0V 40630.0n {vdd} 40800.0n {vdd} 40830.0n 0V 41000.0n 0V 41030.0n {vdd} 41200.0n {vdd} 41230.0n 0V 41400.0n 0V 41430.0n {vdd} 41600.0n {vdd} 41630.0n 0V 41800.0n 0V 41830.0n {vdd} 42000.0n {vdd} 42030.0n 0V 42200.0n 0V 42230.0n 0V 42400.0n 0V 42430.0n 0V 42600.0n 0V 42630.0n {vdd} 42800.0n {vdd} 42830.0n 0V 43000.0n 0V 43030.0n {vdd} 43200.0n {vdd} 43230.0n 0V 43400.0n 0V 43430.0n {vdd} 43600.0n {vdd} 43630.0n 0V 43800.0n 0V 43830.0n {vdd} 44000.0n {vdd} 44030.0n 0V 44200.0n 0V 44230.0n {vdd} 44400.0n {vdd} 44430.0n 0V 44600.0n 0V 44630.0n {vdd} 44800.0n {vdd} 44830.0n 0V 45000.0n 0V 45030.0n {vdd} 45200.0n {vdd} 45230.0n 0V 45400.0n 0V 45430.0n {vdd} 45600.0n {vdd} 45630.0n {vdd} 45800.0n {vdd} 45830.0n {vdd} 46000.0n {vdd} 46030.0n {vdd} 46200.0n {vdd} 46230.0n {vdd} 46400.0n {vdd} 46430.0n {vdd} 46600.0n {vdd} 46630.0n {vdd} 46800.0n {vdd} 46830.0n {vdd} 47000.0n {vdd} 47030.0n {vdd} 47200.0n {vdd} 47230.0n {vdd} 47400.0n {vdd} 47430.0n {vdd} 47600.0n {vdd} 47630.0n {vdd} 47800.0n {vdd} 47830.0n {vdd} 48000.0n {vdd} 48030.0n 0V)
* PWL waveform for A4
VA4 A4 0 PWL(0.0n 0V 30.0n 0V 200.0n 0V 230.0n 0V 400.0n 0V 430.0n 0V 600.0n 0V 630.0n 0V 800.0n 0V 830.0n 0V 1000.0n 0V 1030.0n 0V 1200.0n 0V 1230.0n 0V 1400.0n 0V 1430.0n 0V 1600.0n 0V 1630.0n 0V 1800.0n 0V 1830.0n 0V 2000.0n 0V 2030.0n 0V 2200.0n 0V 2230.0n 0V 2400.0n 0V 2430.0n 0V 2600.0n 0V 2630.0n 0V 2800.0n 0V 2830.0n 0V 3000.0n 0V 3030.0n {vdd} 3200.0n {vdd} 3230.0n 0V 3400.0n 0V 3430.0n {vdd} 3600.0n {vdd} 3630.0n 0V 3800.0n 0V 3830.0n {vdd} 4000.0n {vdd} 4030.0n 0V 4200.0n 0V 4230.0n {vdd} 4400.0n {vdd} 4430.0n 0V 4600.0n 0V 4630.0n {vdd} 4800.0n {vdd} 4830.0n 0V 5000.0n 0V 5030.0n {vdd} 5200.0n {vdd} 5230.0n 0V 5400.0n 0V 5430.0n {vdd} 5600.0n {vdd} 5630.0n 0V 5800.0n 0V 5830.0n {vdd} 6000.0n {vdd} 6030.0n 0V 6200.0n 0V 6230.0n 0V 6400.0n 0V 6430.0n 0V 6600.0n 0V 6630.0n 0V 6800.0n 0V 6830.0n 0V 7000.0n 0V 7030.0n 0V 7200.0n 0V 7230.0n 0V 7400.0n 0V 7430.0n 0V 7600.0n 0V 7630.0n 0V 7800.0n 0V 7830.0n 0V 8000.0n 0V 8030.0n 0V 8200.0n 0V 8230.0n 0V 8400.0n 0V 8430.0n 0V 8600.0n 0V 8630.0n {vdd} 8800.0n {vdd} 8830.0n 0V 9000.0n 0V 9030.0n {vdd} 9200.0n {vdd} 9230.0n 0V 9400.0n 0V 9430.0n {vdd} 9600.0n {vdd} 9630.0n 0V 9800.0n 0V 9830.0n {vdd} 10000.0n {vdd} 10030.0n 0V 10200.0n 0V 10230.0n {vdd} 10400.0n {vdd} 10430.0n 0V 10600.0n 0V 10630.0n {vdd} 10800.0n {vdd} 10830.0n 0V 11000.0n 0V 11030.0n {vdd} 11200.0n {vdd} 11230.0n 0V 11400.0n 0V 11430.0n {vdd} 11600.0n {vdd} 11630.0n 0V 11800.0n 0V 11830.0n 0V 12000.0n 0V 12030.0n 0V 12200.0n 0V 12230.0n 0V 12400.0n 0V 12430.0n 0V 12600.0n 0V 12630.0n 0V 12800.0n 0V 12830.0n 0V 13000.0n 0V 13030.0n 0V 13200.0n 0V 13230.0n 0V 13400.0n 0V 13430.0n 0V 13600.0n 0V 13630.0n 0V 13800.0n 0V 13830.0n {vdd} 14000.0n {vdd} 14030.0n 0V 14200.0n 0V 14230.0n {vdd} 14400.0n {vdd} 14430.0n 0V 14600.0n 0V 14630.0n {vdd} 14800.0n {vdd} 14830.0n 0V 15000.0n 0V 15030.0n {vdd} 15200.0n {vdd} 15230.0n 0V 15400.0n 0V 15430.0n {vdd} 15600.0n {vdd} 15630.0n 0V 15800.0n 0V 15830.0n {vdd} 16000.0n {vdd} 16030.0n 0V 16200.0n 0V 16230.0n {vdd} 16400.0n {vdd} 16430.0n 0V 16600.0n 0V 16630.0n {vdd} 16800.0n {vdd} 16830.0n 0V 17000.0n 0V 17030.0n 0V 17200.0n 0V 17230.0n 0V 17400.0n 0V 17430.0n 0V 17600.0n 0V 17630.0n 0V 17800.0n 0V 17830.0n 0V 18000.0n 0V 18030.0n 0V 18200.0n 0V 18230.0n 0V 18400.0n 0V 18430.0n 0V 18600.0n 0V 18630.0n {vdd} 18800.0n {vdd} 18830.0n 0V 19000.0n 0V 19030.0n {vdd} 19200.0n {vdd} 19230.0n 0V 19400.0n 0V 19430.0n {vdd} 19600.0n {vdd} 19630.0n 0V 19800.0n 0V 19830.0n {vdd} 20000.0n {vdd} 20030.0n 0V 20200.0n 0V 20230.0n {vdd} 20400.0n {vdd} 20430.0n 0V 20600.0n 0V 20630.0n {vdd} 20800.0n {vdd} 20830.0n 0V 21000.0n 0V 21030.0n {vdd} 21200.0n {vdd} 21230.0n 0V 21400.0n 0V 21430.0n {vdd} 21600.0n {vdd} 21630.0n 0V 21800.0n 0V 21830.0n 0V 22000.0n 0V 22030.0n 0V 22200.0n 0V 22230.0n 0V 22400.0n 0V 22430.0n 0V 22600.0n 0V 22630.0n 0V 22800.0n 0V 22830.0n 0V 23000.0n 0V 23030.0n {vdd} 23200.0n {vdd} 23230.0n 0V 23400.0n 0V 23430.0n {vdd} 23600.0n {vdd} 23630.0n 0V 23800.0n 0V 23830.0n {vdd} 24000.0n {vdd} 24030.0n 0V 24200.0n 0V 24230.0n {vdd} 24400.0n {vdd} 24430.0n 0V 24600.0n 0V 24630.0n {vdd} 24800.0n {vdd} 24830.0n 0V 25000.0n 0V 25030.0n {vdd} 25200.0n {vdd} 25230.0n 0V 25400.0n 0V 25430.0n {vdd} 25600.0n {vdd} 25630.0n 0V 25800.0n 0V 25830.0n {vdd} 26000.0n {vdd} 26030.0n 0V 26200.0n 0V 26230.0n 0V 26400.0n 0V 26430.0n 0V 26600.0n 0V 26630.0n 0V 26800.0n 0V 26830.0n 0V 27000.0n 0V 27030.0n {vdd} 27200.0n {vdd} 27230.0n 0V 27400.0n 0V 27430.0n {vdd} 27600.0n {vdd} 27630.0n 0V 27800.0n 0V 27830.0n {vdd} 28000.0n {vdd} 28030.0n 0V 28200.0n 0V 28230.0n {vdd} 28400.0n {vdd} 28430.0n 0V 28600.0n 0V 28630.0n {vdd} 28800.0n {vdd} 28830.0n 0V 29000.0n 0V 29030.0n {vdd} 29200.0n {vdd} 29230.0n 0V 29400.0n 0V 29430.0n {vdd} 29600.0n {vdd} 29630.0n 0V 29800.0n 0V 29830.0n {vdd} 30000.0n {vdd} 30030.0n 0V 30200.0n 0V 30230.0n 0V 30400.0n 0V 30430.0n 0V 30600.0n 0V 30630.0n {vdd} 30800.0n {vdd} 30830.0n 0V 31000.0n 0V 31030.0n {vdd} 31200.0n {vdd} 31230.0n 0V 31400.0n 0V 31430.0n {vdd} 31600.0n {vdd} 31630.0n 0V 31800.0n 0V 31830.0n {vdd} 32000.0n {vdd} 32030.0n 0V 32200.0n 0V 32230.0n {vdd} 32400.0n {vdd} 32430.0n 0V 32600.0n 0V 32630.0n {vdd} 32800.0n {vdd} 32830.0n 0V 33000.0n 0V 33030.0n {vdd} 33200.0n {vdd} 33230.0n 0V 33400.0n 0V 33430.0n {vdd} 33600.0n {vdd} 33630.0n 0V 33800.0n 0V 33830.0n {vdd} 34000.0n {vdd} 34030.0n 0V 34200.0n 0V 34230.0n {vdd} 34400.0n {vdd} 34430.0n 0V 34600.0n 0V 34630.0n {vdd} 34800.0n {vdd} 34830.0n 0V 35000.0n 0V 35030.0n {vdd} 35200.0n {vdd} 35230.0n 0V 35400.0n 0V 35430.0n {vdd} 35600.0n {vdd} 35630.0n 0V 35800.0n 0V 35830.0n {vdd} 36000.0n {vdd} 36030.0n 0V 36200.0n 0V 36230.0n {vdd} 36400.0n {vdd} 36430.0n 0V 36600.0n 0V 36630.0n {vdd} 36800.0n {vdd} 36830.0n {vdd} 37000.0n {vdd} 37030.0n {vdd} 37200.0n {vdd} 37230.0n {vdd} 37400.0n {vdd} 37430.0n {vdd} 37600.0n {vdd} 37630.0n {vdd} 37800.0n {vdd} 37830.0n {vdd} 38000.0n {vdd} 38030.0n {vdd} 38200.0n {vdd} 38230.0n {vdd} 38400.0n {vdd} 38430.0n {vdd} 38600.0n {vdd} 38630.0n {vdd} 38800.0n {vdd} 38830.0n {vdd} 39000.0n {vdd} 39030.0n {vdd} 39200.0n {vdd} 39230.0n {vdd} 39400.0n {vdd} 39430.0n {vdd} 39600.0n {vdd} 39630.0n {vdd} 39800.0n {vdd} 39830.0n {vdd} 40000.0n {vdd} 40030.0n {vdd} 40200.0n {vdd} 40230.0n {vdd} 40400.0n {vdd} 40430.0n {vdd} 40600.0n {vdd} 40630.0n {vdd} 40800.0n {vdd} 40830.0n {vdd} 41000.0n {vdd} 41030.0n {vdd} 41200.0n {vdd} 41230.0n {vdd} 41400.0n {vdd} 41430.0n {vdd} 41600.0n {vdd} 41630.0n {vdd} 41800.0n {vdd} 41830.0n {vdd} 42000.0n {vdd} 42030.0n {vdd} 42200.0n {vdd} 42230.0n {vdd} 42400.0n {vdd} 42430.0n {vdd} 42600.0n {vdd} 42630.0n {vdd} 42800.0n {vdd} 42830.0n {vdd} 43000.0n {vdd} 43030.0n {vdd} 43200.0n {vdd} 43230.0n {vdd} 43400.0n {vdd} 43430.0n {vdd} 43600.0n {vdd} 43630.0n {vdd} 43800.0n {vdd} 43830.0n {vdd} 44000.0n {vdd} 44030.0n {vdd} 44200.0n {vdd} 44230.0n {vdd} 44400.0n {vdd} 44430.0n {vdd} 44600.0n {vdd} 44630.0n {vdd} 44800.0n {vdd} 44830.0n {vdd} 45000.0n {vdd} 45030.0n {vdd} 45200.0n {vdd} 45230.0n {vdd} 45400.0n {vdd} 45430.0n {vdd} 45600.0n {vdd} 45630.0n {vdd} 45800.0n {vdd} 45830.0n {vdd} 46000.0n {vdd} 46030.0n {vdd} 46200.0n {vdd} 46230.0n {vdd} 46400.0n {vdd} 46430.0n {vdd} 46600.0n {vdd} 46630.0n {vdd} 46800.0n {vdd} 46830.0n {vdd} 47000.0n {vdd} 47030.0n {vdd} 47200.0n {vdd} 47230.0n {vdd} 47400.0n {vdd} 47430.0n {vdd} 47600.0n {vdd} 47630.0n {vdd} 47800.0n {vdd} 47830.0n {vdd} 48000.0n {vdd} 48030.0n 0V)
